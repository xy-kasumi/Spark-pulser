# Repository xy-kasumi/Spark-pulser

File README.md:

# Pulser Board

🚧 Under Construction 🚧

Open-source EDM module.

Explicitly designed for plunge EDM.
But probably will work for wire EDM too.

Created for https://github.com/xy-kasumi/Spark project.

## Capability (V2)

* 10A max pulse (see [module spec](./docs/pulser.md) for details)
* Designed for reliablity and modular testability (especially stress testing)

Assembly
* PCB (`pcb/` JLCPCB friendly KiCad files (all manufacturable using "Economical PCBA" process))
  * ctrl-r2
  * hv-r4
  * hc-r3
* firmware (ATtiny1616), for `ctrl` and `hv`
* enclosure: 3D print data in `assy`
* needs a few other parts (12V fans & heatsinks)

# Legacy

There was V1 (repo `PULSER-*` tags).
It was "feature-complete", but lacked reliability & testability.

## KiCad design pcb/pulser-hv/pulser-hv.kicad_pcb

Parts:
C1, C3: 100nF 200V; C_1206_3216Metric; LCSC C113894
C2: 1uF 200V; C_1812_4532Metric; LCSC C3037685
C4, C5, C6: 0.1u; C_0603_1608Metric; LCSC C14663
C14, C15, C16, C17: 0.1u; C_0603_1608Metric
D1, D5: 150V 2A; D_SMC; LCSC C241922
D3: LED; LED_0603_1608Metric; Rating Amber; LCSC C165983
D6: 150V 250mA; D_TUMD2; LCSC C509964
F1: 2A; Fuse_Littelfuse-NANO2-451_453; LCSC C142852
J1, J2: Screw_Terminal 2pin; Wurth_TerminalBlock_2pin_P5mm_691137710002; LCSC C8269
J3: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; LCSC C158012
J6: Conn_01x08_Pin; Molex_200528-0080_1x08-1MP_P1.00mm_Horizontal; LCSC C6074066
Q1: Q_NMOS_GDS; SOT-223-3_TabPin2; LCSC C537930
R1: 100mΩ 120V; R_1206_3216Metric; LCSC C25334
R3: 100k; R_1206_3216Metric; LCSC C17900
R4: 100; RESI-TO263; LCSC C37794578
R6: 1k; R_0603_1608Metric; LCSC C21190
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10: TestPoint_Small; TestPoint_Pad_D1.5mm
U1, U7: ADuM1200AR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C15219
U2: INA281A2; SOT-23-5; LCSC C2908677
U3: LTC7001; MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm; LCSC C690094
U4: TLV3201; SOT-23-5; LCSC C105188

Connections:
+5V: C5.1, C6.1, C16.1, C17.1, U1.8 (VDD2), U2.5 (V+), U4.5 (V+), U7.1 (VDD1); also elsewhere on the board
+12V: C4.1, D6.2 (A), J3.1, U3.1 (VCC); also elsewhere on the board
+36V: F1.2; also elsewhere on the board
/Boost Converter/VOUT: C1.1, C2.1, Q1.2 (D), TP1.1; also elsewhere on the board
/CURR: D3.2 (A), TP10.1, U4.1, U7.2 (VIA); also elsewhere on the board
/CURR_S: J6.4, U7.7 (VOA)
/EN: U1.7 (VOA); also elsewhere on the board
/EN_S: J6.3, U1.2 (VIA)
/GATE: TP7.1, U3.4 (INP); also elsewhere on the board
/VTH: TP8.1, U4.4 (-); also elsewhere on the board
/~FAULT: U7.3 (VIB); also elsewhere on the board
/~FAULT_S: J6.6, U7.6 (VOB)
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C16.2, C17.2, D5.2 (A), J1.1, J2.2, J3.2, R3.2, R4.3, R6.2, U1.5 (GND2), U2.2 (GND), U3.2 (VCCUV), U3.3 (GND), U3.5 (OVLO), U3.11 (GND), U4.2 (V-), U7.4 (GND1); also elsewhere on the board
GNDS: C14.2, C15.2, J6.2, J6.5, U1.3 (VIB), U1.4 (GND1), U7.5 (GND2)
unnamed: D1.2 (A), R4.1, TP4.1
unnamed: D1.1 (K), J2.1, R3.1
unnamed: D3.1 (K), R6.1
unnamed: C3.2, D5.1 (K), Q1.3 (S), R1.1, TP2.1, U2.3 (Vin+), U3.8 (TS)
unnamed: C3.1, D6.1 (K), TP6.1, U3.9 (BST)
unnamed: F1.1, J1.2
unnamed: Q1.1 (G), TP5.1, U3.6 (TGDN), U3.7 (TGUP)
unnamed: TP9.1, U2.1 (OUT), U4.3 (+)
unnamed: R1.2, R4.2, TP3.1, U2.4 (Vin-)
VCCS: C14.1, C15.1, J6.1, U1.1 (VDD1), U7.8 (VDD2)

Notes on the sheet:
CURR
bypass U2, U4
"2": gain=50
peak: 100W avg: 10W Rc-back: <2K/W (150+ vias)
peak: 600mW avg: 60mW
peak: 100mW
IRFL4315
95V
12V fan (500mA max)
94Ω -> 1A
peak: negligible
bypass U3
prevent floating output for easier measurement
operation limiting factor: * avg output current * avg. boost current: 400mW * heat dissipation of limit resistor: 10W (->100mA) * boost conv output cap: duration of single pulse * 1uF (->approx 10us)
400mA max cont->1A pulse 1 pulse:10uC / 1uF: 95uC max duty: 40% (0.4A avg)

Parts:
C7: 0.1u; C_0603_1608Metric; LCSC C14663
C8: 1u; C_0603_1608Metric; LCSC C15849
C26: 1u; C_0402_1005Metric; Rating 10V; LCSC C52923
C27: 10u; C_0603_1608Metric; Rating 24V; LCSC C96446
C29, C30: 1u; C_0603_1608Metric; Rating 50V; LCSC C15849
R9: 110k; R_0402_1005Metric; Rating 1% 20V; LCSC C138065
R10: 10k; R_0402_1005Metric; Rating 1% 10V; LCSC C513708
R14: 270; R_0603_1608Metric; LCSC C22966
R15: 820; R_0603_1608Metric; LCSC C23253
TP12: TestPoint; TestPoint_Pad_D1.5mm
U5: LM317_DPAK; TO-252-2; LCSC C68136
U9: TPSM365R6; TI-RDN0011A-MFG; LCSC C6723000

Connections:
+5V: C8.2, R14.1, U5.2 (VO); also elsewhere on the board
+12V: C7.2, C27.1, R9.1, U5.3 (VI), U9.4 (VOUT); also elsewhere on the board
+36V: C29.1, C30.1, U9.2 (EN), U9.3 (VIN); also elsewhere on the board
GND: C7.1, C8.1, C26.2, C27.2, C29.2, C30.2, R10.2, R15.2, U9.10 (GND), U9.11 (MODE_SYNC); also elsewhere on the board
unnamed: R14.2, R15.1, U5.1 (ADJ)
unnamed: R9.2, R10.1, U9.9 (BIAS)
unnamed: TP12.1, U9.1 (PGOOD)
unnamed: C26.1, U9.8 (VCC)

Notes on the sheet:
RT=0 Fsw=2.2MHz
12VOUT+3V3OUT: max 600mA

Parts:
C21: 0.1u; C_0603_1608Metric; LCSC C14663
D4: LED; LED_0603_1608Metric; Rating Green; LCSC C126319
D7: LED; LED_0603_1608Metric; Rating Red; LCSC C2286
J5: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical; LCSC C7499322
R2, R7: 4.7k; R_0603_1608Metric; LCSC C23162
R20, R21: 100k; R_0603_1608Metric; LCSC C25803
TP11: TestPoint_Small; TestPoint_Pad_D1.5mm
U11: ATtiny1616-M; VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm; LCSC C507118

Connections:
+5V: C21.2, R21.1, U11.4 (VCC); also elsewhere on the board
/CURR: U11.16 (PC1); also elsewhere on the board
/EN: U11.15 (PC0); also elsewhere on the board
/GATE: R20.1, U11.5 (PA4); also elsewhere on the board
/Pulse Controller/UPDI: J5.1, R21.2, U11.19 (~RESET/PA0)
/VTH: U11.7 (PA6); also elsewhere on the board
/~FAULT: U11.14 (PB0); also elsewhere on the board
GND: C21.1, J5.2, R2.2, R7.2, R20.2, U11.3 (GND), U11.21 (GND); also elsewhere on the board
unnamed: D4.2 (A), U11.18 (PC3)
unnamed: D4.1 (K), R7.1
unnamed: D7.2 (A), U11.17 (PC2)
unnamed: D7.1 (K), R2.1
unnamed: TP11.1, U11.20 (PA1)

Notes on the sheet:
FLT
STAT

Parts:
C9: 10uF 50V; C_1206_3216Metric; LCSC C13585
C10: 100nF 200V; C_1206_3216Metric; LCSC C113894
C11: 1u; C_0603_1608Metric; LCSC C15849
C12: 0.22u; C_0603_1608Metric; LCSC C21120
C13: 1n; C_0603_1608Metric; LCSC C1588
D2: 150V 2A; D_SMC; LCSC C241922
L1: 150uH; L_12x12mm_H8mm; Rating Isat=1.8A; LCSC C338769
R16: 430k; R_1206_3216Metric; Rating 1% 150V
R17, R19: 100k; R_0603_1608Metric; LCSC C25803
R18: 7.5k; R_0603_1608Metric; Rating 1%; LCSC C23234
U6: LT8365; AD-MSOP-LT8365; LCSC C673785

Connections:
+36V: C9.1, L1.1, U6.1 (EN/UVLO), U6.3 (VIN); also elsewhere on the board
/Boost Converter/VOUT: C10.1, D2.1 (K), R16.2; also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, C13.2, R18.1, R19.1, U6.7 (BIAS), U6.12 (SYNC/MODE), U6.17 (PGND/GND); also elsewhere on the board
unnamed: C13.1, R17.1
unnamed: D2.2 (A), L1.2, U6.14 (SW2), U6.16 (SW1)
unnamed: R16.1, R18.2, U6.9 (FBX)
unnamed: C11.1, U6.5 (INTVCC)
unnamed: R19.2, U6.10 (RT)
unnamed: C12.1, U6.11 (SS)
unnamed: R17.2, U6.8 (VC)

Notes on the sheet:
Vc: values close to the example
RT=100k -> fosc=400kHz~450kHz
spec: Vo=95V, Iomax=0.4A DMAX=62% eta=90% ILMAX=1.2A ΔISW = 0.6A L = 150uH
FBX=1.6V results in 93V
95V
based on the "9V~30V Input / 125V Output" example in LT8365 datasheet
SYNC/MODE=GND -> Burst Mode
36V

Board: 4 copper layers, 100.0 x 50.0 mm, 74 parts (0 on the bottom side), 41 nets.

File pcb/pulser-hv/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C3",1206,3,100nF 200V,C113894
"C11, C29, C30, C8",0603,4,1u,C15849
C12,0603,1,0.22u,C21120
C13,0603,1,1n,C1588
"C14, C15, C16, C17",0603,4,0.1u,
C2,1812,1,1uF 200V,C3037685
"C21, C4, C5, C6, C7",0603,5,0.1u,C14663
C26,0402,1,1u,C52923
C27,0603,1,10u,C96446
C9,1206,1,10uF 50V,C13585
"D1, D2, D5",D_SMC,3,150V 2A,C241922
D3,0603,1,LED,C165983
D4,0603,1,LED,C126319
D6,D_TUMD2,1,150V 250mA,C509964
D7,0603,1,LED,C2286
F1,Fuse_Littelfuse-NANO2-451_453,1,2A,C142852
"J1, J2",Wurth_TerminalBlock_2pin_P5mm_691137710002,2,Screw_Terminal 2pin,C8269
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,C158012
J5,PinSocket_1x02_P2.54mm_Vertical,1,Conn_01x02_Socket,C7499322
J6,Molex_200528-0080_1x08-1MP_P1.00mm_Horizontal,1,Conn_01x08_Pin,C6074066
L1,L_12x12mm_H8mm,1,150uH,C338769
Q1,SOT-223-3_TabPin2,1,Q_NMOS_GDS,C537930
R1,1206,1,100mΩ 120V,C25334
R10,0402,1,10k,C513708
R14,0603,1,270,C22966
R15,0603,1,820,C23253
R16,1206,1,430k,
"R17, R19, R20, R21",0603,4,100k,C25803
R18,0603,1,7.5k,C23234
"R2, R7",0603,2,4.7k,C23162
R3,1206,1,100k,C17900
R4,RESI-TO263,1,100,C37794578
R6,0603,1,1k,C21190
R9,0402,1,110k,C138065
"U1, U7",SOIC-8_3.9x4.9mm_P1.27mm,2,ADuM1200AR,C15219
U11,VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm,1,ATtiny1616-M,C507118
U2,SOT-23-5,1,INA281A2,C2908677
U3,MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm,1,LTC7001,C690094
U4,SOT-23-5,1,TLV3201,C105188
U5,TO-252-2,1,LM317_DPAK,C68136
U6,AD-MSOP-LT8365,1,LT8365,C673785
U9,TI-RDN0011A-MFG,1,TPSM365R6,C6723000

## KiCad design pcb/pulser-ctrl/pulser-ctrl.kicad_pcb

Parts:
C1, C2: 1u; C_0402_1005Metric; Rating 10V; LCSC C52923
C3, C4, C5: 22u; C_0603_1608Metric; Rating 10V; LCSC C59461
C6, C7: 1u; C_0603_1608Metric; Rating 50V; LCSC C15849
D1: LED; LED_0603_1608Metric; Rating Green; LCSC C126319
D2: LED; LED_0603_1608Metric; Rating Amber; LCSC C510024
D3: LED; LED_0603_1608Metric; Rating Red; LCSC C2286
J1: I2C/XH; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal; LCSC C48641715
J2, J4: Conn_01x08_Pin; Molex_Connector_8pin_P1mm_526100872; LCSC C588214
J3: 36V IN; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical; LCSC C42391660
J5: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
PS1: MEE1S0505SC; Converter_DCDC_Murata_MEE1SxxxxSC_THT; LCSC C7465178
R1: 100k; R_0402_1005Metric; LCSC C25741
R2, R3, R4: 10k; R_0402_1005Metric; LCSC C25744
R5: 40.2k; R_0402_1005Metric; Rating 1%; LCSC C25893
R6: 10k; R_0402_1005Metric; Rating 1%; LCSC C25744
R7: 15.8k; R_0402_1005Metric; Rating 1%; LCSC C26956
TP1, TP2, TP3, TP5, TP6, TP7: TestPoint; TestPoint_Pad_D1.5mm
U1: ATtiny1616-M; VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm; LCSC C507118
U2: TPSM365R6; TI-RDN0011A-MFG; LCSC C6723000

Connections:
+5VS: C1.1, C3.1, J2.1, J4.1, PS1.4 (+Vout), R1.1, TP5.1, U1.4 (VCC)
+36V: C6.1, C7.1, J3.1, U2.2 (EN), U2.3 (VIN)
/5V_NON_ISO: C4.1, C5.1, PS1.2 (+Vin), R5.1, TP6.1, U2.4 (VOUT)
/HC_CURR: J4.4, U1.6 (PA5)
/HC_EN: J4.3, U1.5 (PA4)
/HV_CURR: J2.4, U1.1 (PA2)
/HV_EN: J2.3, U1.20 (PA1)
/HV_~FAULT: J2.6, U1.2 (PA3)
/I2C_SCL: J1.2, U1.14 (PB0)
/I2C_SDA: J1.1, U1.13 (PB1)
/LED_ERR: D3.2 (A), U1.17 (PC2)
/LED_OK: D1.2 (A), U1.15 (PC0)
/LED_RUN: D2.2 (A), U1.16 (PC1)
/UPDI: J5.1, R1.2, U1.19 (~RESET/PA0)
GND: C2.2, C4.2, C5.2, C6.2, C7.2, J3.2, PS1.1 (-Vin), R6.2, R7.2, TP1.1, U2.10 (GND)
GNDS: C1.2, C3.2, J1.3, J2.2, J2.5, J4.2, J4.5, J5.2, PS1.3 (-Vout), R2.2, R3.2, R4.2, TP2.1, U1.3 (GND), U1.21 (GND)
unnamed: D1.1 (K), R2.1
unnamed: D2.1 (K), R3.1
unnamed: D3.1 (K), R4.1
unnamed: TP3.1, U1.18 (PC3)
unnamed: R5.2, R6.1, U2.9 (BIAS)
unnamed: R7.1, U2.11 (MODE_SYNC)
unnamed: TP7.1, U2.1 (PGOOD)
unnamed: C2.1, U2.8 (VCC)

Notes on the sheet:
TODO: confirm these pinouts
to HC board
RT Fsw=1MHz
UPDI writer (5V)
to HV board

Board: 4 copper layers, 40.0 x 45.0 mm, 31 parts (0 on the bottom side), 24 nets.

File pcb/pulser-ctrl/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0402,2,1u,C52923
"C3, C4, C5",0603,3,22u,C59461
"C6, C7",0603,2,1u,C15849
D1,0603,1,LED,C126319
D2,0603,1,LED,C510024
D3,0603,1,LED,C2286
J1,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,I2C/XH,C48641715
"J2, J4",Molex_Connector_8pin_P1mm_526100872,2,Conn_01x08_Pin,C588214
J3,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,1,36V IN,C42391660
J5,PinSocket_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
PS1,Converter_DCDC_Murata_MEE1SxxxxSC_THT,1,MEE1S0505SC,C7465178
R1,0402,1,100k,C25741
"R2, R3, R4, R6",0402,4,10k,C25744
R5,0402,1,40.2k,C25893
R7,0402,1,15.8k,C26956
U1,VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm,1,ATtiny1616-M,C507118
U2,TI-RDN0011A-MFG,1,TPSM365R6,C6723000

## KiCad design pcb/pulser-hc/pulser-hc.kicad_pcb

Parts:
C8: 220n; C_0603_1608Metric; Rating 10V; LCSC C21120
C9: 1u; C_0805_2012Metric; Rating 50V; LCSC C28323
C12: 22n; C_0805_2012Metric; Rating 200V; LCSC C5128361
C33, C35: 0.1u; C_0402_1005Metric; Rating 10V; LCSC C307331
D1: VISHAY-SMPC; Rating 120V 10A; LCSC C968542
D5: Vz=100V; D_SMB; Rating 3W; LCSC C150045
D6: TO-227A-2P; Rating 150V 2A; LCSC C2927414
D7: LED; LED_0805_2012Metric; Rating Green; LCSC C2297
D8: LED; LED_0805_2012Metric; Rating Amber; LCSC C5123498
F1: 10A; Fuse_Littelfuse-NANO2-451_453; LCSC C44479
J1, J2: Screw_Terminal 2pin; Wurth_TerminalBlock_2pin_P5mm_691137710002; LCSC C8269
J3: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: Conn_01x08_Pin; Molex_200528-0080_1x08-1MP_P1.00mm_Horizontal; LCSC C6074066
R11: 3.3; R_2512_6332Metric; Rating 200V 2W; LCSC C2960811
R12: 10k; R_0402_1005Metric; Rating 10V; LCSC C25744
R16, R19: 1k; R_0402_1005Metric; Rating 10V; LCSC C11702
R24: 1; R_2512_6332Metric; Rating 1W; LCSC C3000711
TP8: TestPoint; TestPoint_Pad_D1.5mm
U1: ADuM1200AR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C15219

Connections:
+3V3: C35.1, D7.2 (A), U1.8 (VDD2); also elsewhere on the board
+12V: J3.1; also elsewhere on the board
+36V: C9.1, F1.2; also elsewhere on the board
/CURR_CTRL: C8.2, R12.2, TP8.1; also elsewhere on the board
/CURR_S: J6.4, U1.3 (VIB)
/EN: D8.2 (A), U1.7 (VOA); also elsewhere on the board
/EN_S: J6.3, U1.2 (VIA)
/highcurrent/VOUT: D1.2 (A); also elsewhere on the board
GND: C8.1, C35.2, D5.2 (A), D6.2 (A), J1.1, J2.2, J3.2, R11.2, R16.1, R19.1, R24.2, U1.5 (GND2); also elsewhere on the board
GNDS: C33.2, J6.2, J6.5, U1.4 (GND1)
unnamed: C9.2, R24.1
unnamed: C12.1, R11.1
unnamed: C12.2, D1.1 (K), D5.1 (K), D6.1 (K), J2.1
unnamed: D7.1 (K), R16.2
unnamed: D8.1 (K), R19.2
unnamed: F1.1, J1.2
unnamed: R12.1, U1.6 (VOB)
VCCS: C33.1, J6.1, U1.1 (VDD1)

Notes on the sheet:
stray inductance flywheel
Snubber (R=3.3Ω, C=20nF)
VCCS=3.3V or 5V current draw: <5mA
fc=72Hz LPF (9kHz 50% -> 1%- ripple)
D1 protection
resonance damper for cable inductance
Thermal environment * via: 300K/W * backside-air: 1.7K/W (only where heatsink exists) * Tair=30C
6W target: Tj<100C 50 vias
min pulse width: 1us
CURR (PWM) * accepted freq: 10kHz~200kHz * working range: 22%(5A) ~ 45% (10A) (0.22A/%) * setting delay: 10ms Below 22%: output current might be unstable compared to ripple Above 45%: clamped to 10A
PWR
1.6W (at 8kHz pulse) target: Tj<100C 22 vias (assuming Tjc=20K/W)
12V fan (max 200mA)

Parts:
C15: 0.1u; C_0402_1005Metric; Rating 24V; LCSC C307331
C16: 0.1u; C_0402_1005Metric; Rating 10V; LCSC C307331
C26: 1u; C_0402_1005Metric; Rating 10V; LCSC C52923
C27: 10u; C_0603_1608Metric; Rating 24V; LCSC C96446
C29, C30: 1u; C_0603_1608Metric; Rating 50V; LCSC C15849
R14: 110k; R_0402_1005Metric; Rating 1% 20V; LCSC C138065
R15: 10k; R_0402_1005Metric; Rating 1% 10V; LCSC C513708
R17: 240; R_0402_1005Metric; Rating 10V; LCSC C852660
R18: 390; R_0402_1005Metric; Rating 10V; LCSC C137997
TP12: TestPoint; TestPoint_Pad_D1.5mm
U2: LM317_DPAK; TO-252-2; LCSC C68136
U4: TPSM365R6; TI-RDN0011A-MFG; LCSC C6723000

Connections:
+3V3: C16.2, R17.1, U2.2 (VO); also elsewhere on the board
+12V: C15.2, C27.1, R14.1, U2.3 (VI), U4.4 (VOUT); also elsewhere on the board
+36V: C29.1, C30.1, U4.2 (EN), U4.3 (VIN); also elsewhere on the board
GND: C15.1, C16.1, C26.2, C27.2, C29.2, C30.2, R15.2, R18.2, U4.10 (GND), U4.11 (MODE_SYNC); also elsewhere on the board
unnamed: R17.2, R18.1, U2.1 (ADJ)
unnamed: R14.2, R15.1, U4.9 (BIAS)
unnamed: TP12.1, U4.1 (PGOOD)
unnamed: C26.1, U4.8 (VCC)

Notes on the sheet:
3.3V
12VOUT+3V3OUT: max 600mA
RT=0 Fsw=2.2MHz
