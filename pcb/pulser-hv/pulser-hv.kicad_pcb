# Repository xy-kasumi/Spark-pulser (continued)

## KiCad design pcb/pulser-hc/pulser-hc.kicad_pcb (continued)

Parts:
C1, C4: 1n; C_0402_1005Metric; Rating 50V; LCSC C1523
C2: 220n; C_0603_1608Metric; Rating 24V; LCSC C21120
C3: 22n; C_0402_1005Metric; Rating 10V; LCSC C1532
C5, C19, C20: 10u; C_0805_2012Metric; Rating 10V; LCSC C1713
C6: 470p; C_0402_1005Metric; Rating 10V; LCSC C26412
C7: 4.7n; C_0402_1005Metric; Rating 10V; LCSC C1538
C10, C11, C21, C23, C24, C25: 10u; C_1206_3216Metric; Rating 50V; LCSC C13585
C14: 2.2u; C_0603_1608Metric; Rating 10V; LCSC C23630
C17, C18: 10n; C_0402_1005Metric; Rating 50V; LCSC C15195
C22: 10u; C_1206_3216Metric; Rating 50V; LCSC C89632
D2: D_SOD-123; Rating 100mA; LCSC C177047
D3: D; D_SOD-123; Rating 500mA; LCSC C177047
D4: Ipeak>10A; TO-227A-2P; LCSC C2927414
JP1: Jumper_2_Small_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 10u; L_Bourns_SRP1245A; LCSC C840531
Q1: N-ch, Vds>=60V, low Qgs; Infineon-TG-TDSON-8-NMOS; LCSC C3278729
Q2: N-ch, Vds>=60V, low Rds; Infineon-TG-TDSON-8-NMOS; LCSC C501503
R1, R6: 1; R_1206_3216Metric; Rating 50V; LCSC C2759212
R2: 5m; R_1206_3216Metric; Rating 50V; LCSC C7419996
R3, R4: 10; R_0402_1005Metric; Rating 50V; LCSC C25077
R5: 62k; R_0402_1005Metric; Rating 50V; LCSC C423271
R7: 2.7k; R_0402_1005Metric; Rating 10V; LCSC C423290
R8: 33k; R_0402_1005Metric; Rating 10V; LCSC C728559
R9: 82k; R_0402_1005Metric; Rating 50V; LCSC C852929
R10: 120k; R_0402_1005Metric; Rating 10V; LCSC C144802
R13, R25: 47k; R_0402_1005Metric; Rating 10V; LCSC C25792
R26: 4.3k; R_0402_1005Metric; Rating 50V; LCSC C852817
TP1, TP2, TP3, TP4, TP5, TP9, TP10, TP15, TP16, TP18: TestPoint; TestPoint_Pad_D1.5mm
U3: LT3763; TSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.74x4.75mm; LCSC C459912

Connections:
+36V: C10.2, C11.2, C21.2, C22.2, D4.1 (K), Q1.D, R1.1, R9.1, U3.3 (VIN), U3.6 (IVINN), U3.7 (IVINP); also elsewhere on the board
/CURR_CTRL: D3.2 (A), U3.14 (CTRL1); also elsewhere on the board
/EN: U3.22 (PWM); also elsewhere on the board
/highcurrent/CTRL2: R13.2, U3.13 (CTRL2)
/highcurrent/EN: R9.2, R26.1, U3.4 (EN/UVLO)
/highcurrent/INTVCC: C5.2, C19.2, C20.2, D2.2 (A), R25.2, TP9.1, U3.2 (INTVCC)
/highcurrent/RT: R10.1, U3.20 (RT)
/highcurrent/SENSE+: C3.2, R3.2, U3.17 (SENSE+)
/highcurrent/SENSE-: C3.1, R4.2, U3.16 (SENSE-)
/highcurrent/SS: C6.2, U3.15 (SS)
/highcurrent/SYNC: JP1.2 (B), U3.21 (SYNC)
/highcurrent/VC: R8.1, U3.18 (VC)
/highcurrent/VOUT: C17.2, C18.2, C23.2, C24.2, C25.2, D4.2 (A), R2.2, R4.1, R5.1, TP4.1; also elsewhere on the board
/highcurrent/VREF: C14.2, D3.1 (K), R13.1, U3.5 (VREF), U3.10 (FBIN)
/highcurrent/~FAULT: R25.1, TP18.1, U3.9 (~FAULT)
GND: C4.1, C5.1, C6.1, C7.1, C10.1, C11.1, C14.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, JP1.1 (A), Q2.S, R7.2, R10.2, R26.2, U3.12 (GND), U3.23 (GND), U3.28 (GND), U3.29 (GND); also elsewhere on the board
unnamed: C1.2, R1.2
unnamed: C4.2, R6.2
unnamed: C7.2, R8.2
unnamed: C2.2, D2.1 (K), TP10.1, U3.27 (BOOST)
unnamed: L1.2, R2.1, R3.1, TP3.1
unnamed: Q2.G, TP5.1, U3.1 (BG)
unnamed: R5.2, R7.1, U3.11 (FB)
unnamed: TP16.1, U3.19 (ISMON)
unnamed: TP15.1, U3.8 (IVINMON)
unnamed: C1.1, C2.1, L1.1, Q1.S, Q2.D, R6.1, TP2.1, U3.26 (SW)
unnamed: Q1.G, TP1.1, U3.25 (TG)

Notes on the sheet:
0.5W
BSC094N06LS5
0.4W cond: 0.4W
protection
3.1W cond: 1.4W sw: 1.7W -> 17vias
22uF is recommended in datasheet account for cap loss by DC-bias 16V+ is recommended
2uFx10 = 20uF is recommended 30uF is DC-bias accounted value
fc=723kHz
over-voltage protection 36V (current limited above 29V) FB(OVP)=1.5V FB(limit)=1.21V
BSC0702LS
output current conf (0.15V/A) * working range: 0.75V (5A) ~ 1.5V (10A) below 0.75V (5A): * output current can become unstable * rise time can become too small above 1.5V (10A): * saturates at 1.5V (10A) abs max * clipped at 2V (clamping diode: max 500mA) * for input>2V, its impedance must be high e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
MOSFET
fs=350kHz
Isat>12A
computed using Vo=20V
30V UVLO (1.5V thresh)
Tstart=30us

Board: 4 copper layers, 100.0 x 50.0 mm, 85 parts (0 on the bottom side), 44 nets.

File pcb/pulser-hc/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C4",0402,2,1n,C1523
"C10, C11, C21, C23, C24, C25",1206,6,10u,C13585
C12,0805,1,22n,C5128361
C14,0603,1,2.2u,C23630
"C15, C16, C33, C35",0402,4,0.1u,C307331
"C17, C18",0402,2,10n,C15195
"C19, C20, C5",0805,3,10u,C1713
"C2, C8",0603,2,220n,C21120
C22,1206,1,10u,C89632
C26,0402,1,1u,C52923
C27,0603,1,10u,C96446
"C29, C30",0603,2,1u,C15849
C3,0402,1,22n,C1532
C6,0402,1,470p,C26412
C7,0402,1,4.7n,C1538
C9,0805,1,1u,C28323
D1,VISHAY-SMPC,1,~,C968542
D2,D_SOD-123,1,~,C177047
D3,D_SOD-123,1,D,C177047
D4,TO-227A-2P,1,Ipeak>10A,C2927414
D5,D_SMB,1,Vz=100V,C150045
D6,TO-227A-2P,1,~,C2927414
D7,0805,1,LED,C2297
D8,0805,1,LED,C5123498
F1,Fuse_Littelfuse-NANO2-451_453,1,10A,C44479
"J1, J2",Wurth_TerminalBlock_2pin_P5mm_691137710002,2,Screw_Terminal 2pin,C8269
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
J6,Molex_200528-0080_1x08-1MP_P1.00mm_Horizontal,1,Conn_01x08_Pin,C6074066
L1,L_Bourns_SRP1245A,1,10u,C840531
Q1,Infineon-TG-TDSON-8-NMOS,1,"N-ch, Vds>=60V, low Qgs",C3278729
Q2,Infineon-TG-TDSON-8-NMOS,1,"N-ch, Vds>=60V, low Rds",C501503
"R1, R6",1206,2,1,C2759212
R10,0402,1,120k,C144802
R11,2512,1,3.3,C2960811
R12,0402,1,10k,C25744
"R13, R25",0402,2,47k,C25792
R14,0402,1,110k,C138065
R15,0402,1,10k,C513708
"R16, R19",0402,2,1k,C11702
R17,0402,1,240,C852660
R18,0402,1,390,C137997
R2,1206,1,5m,C7419996
R24,2512,1,1,C3000711
R26,0402,1,4.3k,C852817
"R3, R4",0402,2,10,C25077
R5,0402,1,62k,C423271
R7,0402,1,2.7k,C423290
R8,0402,1,33k,C728559
R9,0402,1,82k,C852929
U1,SOIC-8_3.9x4.9mm_P1.27mm,1,ADuM1200AR,C15219
U2,TO-252-2,1,LM317_DPAK,C68136
U3,TSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.74x4.75mm,1,LT3763,C459912
U4,TI-RDN0011A-MFG,1,TPSM365R6,C6723000

## KiCad design pcb/PULSER/PULSER.kicad_pcb

Parts:
C8: 10nF; C_0603_1608Metric; LCSC C57112
D1: White LED; LED_0603_1608Metric; LCSC C2290
F1: 20A; Fuse_Littelfuse-NANO2-451_453; LCSC C178980
FB1, FB2: FerriteBead_Small; L_0603_1608Metric; LCSC C88986
J1, J4, J5: Screw_Terminal 2pin; Wurth_TerminalBlock_2pin_P5mm_691137710002; LCSC C8269
J2: XH 2pin; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical; LCSC C161869
J7: XH 3pin; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical; LCSC C161870
JP1, JP2: Jumper_2_Bridged; HoTCu-10.2D-0R; LCSC C5127898
R1: 1k; R_0603_1608Metric; LCSC C21190
TP2, TP6, TP7, TP8, TP10, TP11, TP12, TP13, TP14, TP16, TP18, TP20, TP35, TP36: TestPoint_Small; TestPoint_Pad_D1.5mm
U12: TMP102; SOT-563; LCSC C99269

Connections:
+3V3: C8.1, TP7.1, U12.4 (ADD0), U12.5 (V+); also elsewhere on the board
+5V: TP6.1; also elsewhere on the board
+12V: J2.1, J4.2; also elsewhere on the board
/+36V: F1.1, J1.2
/I2C_SCL: FB2.2, TP20.1; also elsewhere on the board
/I2C_SDA: FB1.2, TP18.1; also elsewhere on the board
/Mux/V0_L: TP14.1; also elsewhere on the board
/Mux/V+: TP10.1; also elsewhere on the board
/Mux/V-: TP11.1; also elsewhere on the board
/Mux/VC_L: TP16.1; also elsewhere on the board
/Mux/VOUT_0: JP1.1 (A); also elsewhere on the board
/Mux/VOUT_COM: JP2.1 (A); also elsewhere on the board
/Pico2/CURR_DETECT: TP13.1; also elsewhere on the board
/Pico2/GATE_IG: TP8.1; also elsewhere on the board
/Pico2/GATE_MAIN_PWM: TP12.1; also elsewhere on the board
/Pico2/LED_STATUS: D1.2 (A); also elsewhere on the board
/Pico2/TS_I2C_SCL: TP36.1, U12.1 (SCL); also elsewhere on the board
/Pico2/TS_I2C_SDA: TP35.1, U12.6 (SDA); also elsewhere on the board
GND: C8.2, J1.1, J2.2, J4.1, J7.3, R1.2, U12.2 (GND); also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: J5.1, JP1.2 (B)
unnamed: J5.2, JP2.2 (B)
unnamed: FB1.1, J7.1
unnamed: FB2.1, J7.2
VPWR: F1.2, TP2.1; also elsewhere on the board

Notes on the sheet:
Max 100V, 20A
Rating
Input1: 36V 16A Input2: 12V 2A Pulse ignition voltage: 100V Pulse current (max): 20A
to fan in pulse shaper XH Connector 12V, 500mA-
mainly protects against shoot-through by firmware bug
All signals are 3.3V digital
middle of hot area measures chip/PCB temp don't connect to heatsink
36V 16A
Hot area Needs active cooling
12V ?A
* HVHC: High Voltage (100V), High Current (10A+) * HC: High Current (10A+) * HV: High Voltage (100V) * PWR: Normal power line (~few Amps)
TOOL
500ksps ADC
Netclass
WORK/GRIND

Parts:
C3: 1uF 50V; C_0603_1608Metric; LCSC C15849
U2: L78M05ABDT; TO-252-2; LCSC C58069

Connections:
+5V: U2.3 (VO); also elsewhere on the board
+12V: C3.1, U2.1 (VCC); also elsewhere on the board
GND: C3.2, U2.2 (GND); also elsewhere on the board

Notes on the sheet:
Rating
Input: 12V Output: 5V, 1A (peak), 100mA (nominal)

Notes on the sheet:
100V, 20A switching
Control Requirements
Rating
4W heat output Passive heatsink or no heatsink 1.1W x 4 = 4.4W On Power: (20A/2)^2 x 11mΩ = 1.1W
User is responsible for shoot-through prevention Low-side of unused output must be H (at least ocassionally) to charge gate driver's bootstrap capacitor.
Thermal

Parts:
C4: 1uF; C_0603_1608Metric; LCSC C15849
D8, D9: Schottky Diode; D_SOD-323; LCSC C191023
J8, J9: Socket 20pin, 2.54mm; PinSocket_1x20_P2.54mm_Vertical; LCSC C5224030
R23, R24, R25, R26: 10k; R_0603_1608Metric; LCSC C25804
TP31: TestPoint_Small; TestPoint_Pad_D1.5mm
U6: REF3030; SOT-23; LCSC C38423

Connections:
+3V3: J9.16, R23.2, R24.2, R25.2, R26.2; also elsewhere on the board
+5V: C4.1, D8.2 (A), U6.1 (IN); also elsewhere on the board
/I2C_SCL: J8.2, R24.1; also elsewhere on the board
/I2C_SDA: J8.1, R23.1; also elsewhere on the board
/Mux/V0_L: J8.10; also elsewhere on the board
/Mux/VC_L: J8.12; also elsewhere on the board
/Pico2/3VREF: D9.1 (K), J9.15, TP31.1, U6.2 (OUT)
/Pico2/5VPROT: D8.1 (K), J9.19
/Pico2/CURR_DETECT: D9.2 (A), J9.11; also elsewhere on the board
/Pico2/GATE_IG: J9.2; also elsewhere on the board
/Pico2/GATE_MAIN_PWM: J9.4; also elsewhere on the board
/Pico2/LED_STATUS: J8.6; also elsewhere on the board
/Pico2/TS_I2C_SCL: J8.20, R26.1; also elsewhere on the board
/Pico2/TS_I2C_SDA: J8.19, R25.1; also elsewhere on the board
GND: C4.2, J8.3, J8.8, J8.13, J8.18, J9.3, J9.8, J9.13, J9.18, U6.3 (GND); also elsewhere on the board

Notes on the sheet:
Should set PS=1 (GPIO23) to decrease voltage ripple

Parts:
C5: 1uF 200V; C_1812_4532Metric; LCSC C3037685
C7, C16, C19, C27: 100nF 50V; C_0603_1608Metric; LCSC C14663
C10, C11, C12, C13, C14, C28, C31, C32: 10uF 50V; C_1206_3216Metric; LCSC C13585
C15, C23: 1uF 50V; C_0603_1608Metric; LCSC C15849
C29: 100nF; C_0603_1608Metric; LCSC C14663
C30: 470pF; C_0603_1608Metric; LCSC C1620
C33, C34: 1nF 50V; C_0603_1608Metric; LCSC C1588
D2: Dual Schottky Diode, Common K; TO-263-2; LCSC C180497
D3: Red LED; LED_0603_1608Metric; LCSC C2286
D4: 150V 1A, Schottky; D_SOD-323HE; LCSC C2842811
D12: 130V, Zener; D_SMB; LCSC C236106
L1: 1u; L_12x12mm_H6mm; LCSC C230666
L4: 10u; BOURNS-PQ2614B; LCSC C1330029
NT4: NetTie_2; NetTie-2_SMD_Pad2.0mm
NT5, NT6, NT7: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q2, Q6: N-ch, Vds>=60V, fast switch, low Rds; Infineon-TG-TDSON-8-NMOS; LCSC C24199
Q7, Q8: N-ch, Vds>=200V, fast switch, low Rds; Infineon-TG-TDSON-8-NMOS; LCSC C501501
R2: 200; R_2512_6332Metric; LCSC C2765767
R3: 100k 150V; R_0805_2012Metric; LCSC C122537
R14: 10k; R_0603_1608Metric; LCSC C25804
R16, R17, R21, R27: 10; R_0603_1608Metric; LCSC C22859
R36, R37: 1; R_1210_3225Metric; LCSC C78022
TP4, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP33, TP39: TestPoint_Small; TestPoint_Pad_D1.5mm
U1: LM5104MX/NOPB; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C206493
U3: ACS724LLCTR-30AU; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2155519
U5: IR2104S; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2960

Connections:
+5V: C29.2, U3.8 (VCC); also elsewhere on the board
+12V: C15.1, C23.1, D4.2 (A), U1.1 (VDD), U5.1 (VCC), U5.3 (~SD); also elsewhere on the board
/Mux/V+: D2.2 (K), D12.1 (K), NT7.2; also elsewhere on the board
/Mux/V-: D3.1 (K), D12.2 (A), U3.1 (IP+), U3.2 (IP+); also elsewhere on the board
/Pico2/CURR_DETECT: U3.7 (VIOUT); also elsewhere on the board
/Pico2/GATE_IG: U5.2 (IN); also elsewhere on the board
/Pico2/GATE_MAIN_PWM: U1.6 (IN); also elsewhere on the board
/Pulse Shaper/Boost Converter 100V/VOUT: NT4.1; also elsewhere on the board
GND: C5.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C19.1, C23.2, C27.1, C28.2, C29.1, C30.1, C31.2, C32.2, L4.3, Q2.S, Q8.S, R14.2, R36.2, U1.7 (VSS), U3.3 (IP-), U3.4 (IP-), U3.5 (GND), U5.4 (COM); also elsewhere on the board
unnamed: C5.1, NT4.2, R2.1
unnamed: C10.1, C11.1, C12.1, C13.1, C19.2, C27.2, C34.2, L1.2, Q6.D, TP29.1
unnamed: C33.1, R36.1
unnamed: C33.2, L4.2, NT6.1, Q2.D, Q6.S, R37.2, TP28.1
unnamed: C34.1, R37.1
unnamed: D2.1 (A), L4.1, TP26.1
unnamed: D2.3 (A), NT5.1, Q7.S, Q8.D, TP25.1
unnamed: D3.2 (A), R3.2
unnamed: C7.1, D4.1 (K), TP33.1, U5.8 (VB)
unnamed: NT7.1, R3.1
unnamed: Q2.G, R17.1, TP27.1
unnamed: Q6.G, R16.2, TP24.1
unnamed: Q7.D, R2.2, TP23.1
unnamed: Q7.G, R21.1, TP4.1
unnamed: Q8.G, R27.1, TP39.1
unnamed: C16.1, TP30.1, U1.2 (HB)
unnamed: R16.1, U1.3 (HO)
unnamed: C16.2, NT6.2, U1.4 (HS)
unnamed: R17.2, U1.8 (LO)
unnamed: R14.1, U1.5 (RT)
unnamed: C30.2, U3.6 (FILTER)
unnamed: R21.2, U5.7 (HO)
unnamed: R27.2, U5.5 (LO)
unnamed: C7.2, NT5.2, U5.6 (VS)
VPWR: C14.1, C28.1, C31.1, C32.1, L1.1; also elsewhere on the board

Notes on the sheet:
133mV/A, can exceed 3.3V
L1 (PCB layout & height compatible) * Sumida 125CDMCCDS-1R0MC * BOURNS SRP1245A-1R0M L4 (probably PCB layout compatible) * Ruishen RSPQ2918-100M * FANGCHENG FC-SE2915-100M D2 * STMicro STPS40170CG-TR D12 * onsemi 1SMB5951BT3G (Vz=120V instead of 130V) Q7,Q7 * infineon BSC350N20NSFD (almost same) * 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
fc=180kHz (R_Fint=1.8k) Accuracy doesn't matter too much. But fc shouldn't be too low compared to sensor BW. ADC sampling: 400kHz, Fnyquist=200kHz.
Cboot>6nF
Cboot>12nF
BSC067N06LS3G VDss=60V Rdson=6.7mOhm
0.4W height=1.0mm (area: 6.1x5.3), RΘJC=1C/W -- On Power: 20A^2 x 0.032Ω x 2.5% = 0.3W where 2.5% = 5us / 200us Sw Power: 0.5 x 100V x 20A x (9ns+4ns) x 10kHz = 0.1W
Forward Operation (E+ < E-) fly-wheeling load inductive current
500kHz PWM
PQ2614BHA-100K Rdc=1.6mOhm
36V
Reverse Operation (E+ >> E-) Zener: protect power supply when load is suddenly disconnected
30W max heat output Heatsink Rθ<1.5C/W (3cm)^3-ish heatsink + active cooling (1+m/s) is OK Bootleneck is case-heatsink TIM Use thin (less than 0.5mm) TIM + metal shim 0.5mm silicone thermal pad: Rθ= 1.0 / A[cm^2]
Thermal
1.0W height=5.0mm (area: 10x10) --
9.6W (each MOSFET) height=1.0mm (area: 6.1x5.3), RΘJC=1.8C/W -- @Tj=100C On Power: 20A^2 x 9mΩ = 3.6W Sw Power: 0.5 x 36V x 20A x (26ns+7ns) * 500kHz = 6W
deadtime(eff)=60ns
BSC320N20NS3G VDss=200V Rdson=32mOhm
Alternative Parts Sourcing
ETQP5M1R0YLC Rdc=2.3mOhm
discharge parasitic capacitance for safety & indicates hot electrodes
P=1nF x (36V)^2 x 500kHz = 0.6W
RB238NS150TL 150V, 20A/diode Vf=700mV@I=20A,Tj=75C
Ip <= 20A 100us <= Tp
LC filter fc≒25kHz
14W height=4.5mm (area: 10.1x9.0) RθJC(single)=0.86C/W -- 20A x 0.7V = 14W
Rating

Parts:
C24: 100nF 50V; C_0603_1608Metric; LCSC C14663
C26: 1uF 50V; C_0603_1608Metric; LCSC C15849
D10: 150V 1A, Schottky; D_SOD-323HE; LCSC C2842811
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q16, Q17, Q18, Q20: N-ch, Vds>=200V, fast switch, low Rds; Infineon-TG-TDSON-8-NMOS; LCSC C412739
R28, R30, R32, R34: 10; R_0603_1608Metric; LCSC C22859
TP37, TP40, TP43: TestPoint_Small; TestPoint_Pad_D1.5mm; not fitted
U10: IR2104S; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2960

Connections:
+12V: C26.1, D10.2 (A), U10.1 (VCC), U10.3 (~SD); also elsewhere on the board
/Mux/V+: Q16.D, Q18.D; also elsewhere on the board
/Mux/V-: Q17.S, Q20.S; also elsewhere on the board
/Mux/VC_L: U10.2 (IN); also elsewhere on the board
/Mux/VOUT_COM: NT1.1, Q16.S, Q17.D, Q18.S, Q20.D; also elsewhere on the board
GND: C26.2, U10.4 (COM); also elsewhere on the board
unnamed: C24.2, D10.1 (K), U10.8 (VB)
unnamed: Q16.G, R28.1
unnamed: Q17.G, R30.1
unnamed: Q18.G, R34.1
unnamed: Q20.G, R32.1
unnamed: R28.2, R34.2, U10.7 (HO)
unnamed: R30.2, R32.2, U10.5 (LO)
unnamed: C24.1, NT1.2, U10.6 (VS)

Parts of its further copies:
C9: 100nF 50V; C_0603_1608Metric; LCSC C14663
C25: 1uF 50V; C_0603_1608Metric; LCSC C15849
D6: 150V 1A, Schottky; D_SOD-323HE; LCSC C2842811
NT2: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q14, Q15, Q19, Q21: N-ch, Vds>=200V, fast switch, low Rds; Infineon-TG-TDSON-8-NMOS; LCSC C412739
R29, R31, R33, R35: 10; R_0603_1608Metric; LCSC C22859
U8: IR2104S; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2960

Connections of its further copies:
+12V: C25.1, D6.2 (A), U8.1 (VCC), U8.3 (~SD); also elsewhere on the board
/Mux/V0_L: U8.2 (IN); also elsewhere on the board
/Mux/V+: Q14.D, Q19.D; also elsewhere on the board
/Mux/V-: Q15.S, Q21.S; also elsewhere on the board
/Mux/VOUT_0: NT2.1, Q14.S, Q15.D, Q19.S, Q21.D; also elsewhere on the board
GND: C25.2, U8.4 (COM); also elsewhere on the board
unnamed: C9.2, D6.1 (K), U8.8 (VB)
unnamed: Q14.G, R29.1
unnamed: Q15.G, R31.1
unnamed: Q19.G, R35.1
unnamed: Q21.G, R33.1
unnamed: R29.2, R35.2, U8.7 (HO)
unnamed: R31.2, R33.2, U8.5 (LO)
unnamed: C9.1, NT2.2, U8.6 (VS)

Notes on the sheet:
BSC110N15NS5
