# Repository xy-kasumi/Spark-pulser (continued)

## KiCad design pcb/PULSER/PULSER.kicad_pcb (continued)

Parts:
C17: 10uF 50V; C_1206_3216Metric; LCSC C13585
C18: 100nF 200V; C_0805_2012Metric; LCSC C342865
C20: 1uF; C_0603_1608Metric; LCSC C15849
C21: 0.22uF; C_0603_1608Metric; LCSC C21120
C22: 1nF; C_0603_1608Metric; LCSC C1588
D7: 150V 1A, Schottky bigger; D_PowerDI-123; LCSC C156325
L2: 100uH, Isat=2.7A; L_12x12mm_H8mm; LCSC C2453104
R18: 470k 150V; R_0805_2012Metric; LCSC C17709
R19, R22: 100k; R_0603_1608Metric; LCSC C25803
R20: 7.5k; R_0603_1608Metric; LCSC C23234
TP32, TP34: TestPoint_Small; TestPoint_Pad_D1.5mm
U4: LT8365; AD-MSOP-LT8365; LCSC C673785

Connections:
/Pulse Shaper/Boost Converter 100V/LOUT: D7.2 (A), L2.2, TP32.1, U4.14 (SW2), U4.16 (SW1)
/Pulse Shaper/Boost Converter 100V/VODIV: R18.1, R20.2, TP34.1, U4.9 (FBX)
/Pulse Shaper/Boost Converter 100V/VOUT: C18.1, D7.1 (K), R18.2; also elsewhere on the board
GND: C17.2, C18.2, C20.2, C21.2, C22.2, R20.1, R22.1, U4.7 (BIAS), U4.12 (SYNC/MODE), U4.17 (PGND/GND); also elsewhere on the board
unnamed: C22.1, R19.1
unnamed: C20.1, U4.5 (INTVCC)
unnamed: R22.2, U4.10 (RT)
unnamed: C21.1, U4.11 (SS)
unnamed: R19.2, U4.8 (VC)
VPWR: C17.1, L2.1, U4.1 (EN/UVLO), U4.3 (VIN); also elsewhere on the board

Notes on the sheet:
Output: 100V, 100mA
Vc: values close to the example
Alternative Parts Sourcing
DMAX=64% eta=50% ILMAX=550mA ΔISW = 0.6A (< 1.9A) L = 96uH
L2 (PCB layout) * Sumida CDRH127NP-101MC * PROD Tech PSPHAQ127-101M
100V
FBX=1.6V results in 102V
based on the "9V~30V Input / 125V Output" example in LT8365 datasheet
SYNC/MODE=GND -> Burst Mode
36V
Rating
RT=100k -> fosc=400kHz~450kHz

Board: 4 copper layers, 150.0 x 100.0 mm, 137 parts (0 on the bottom side), 75 nets.

File pcb/PULSER/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C10, C11, C12, C13, C14, C17, C28, C31, C32",1206,9,10uF 50V,C13585
"C15, C23, C25, C26, C3",0603,5,1uF 50V,C15849
"C16, C19, C24, C27, C7, C9",0603,6,100nF 50V,C14663
C18,0805,1,100nF 200V,C342865
"C20, C4",0603,2,1uF,C15849
C21,0603,1,0.22uF,C21120
C22,0603,1,1nF,C1588
C29,0603,1,100nF,C14663
C30,0603,1,470pF,C1620
"C33, C34",0603,2,1nF 50V,C1588
C5,1812,1,1uF 200V,C3037685
C8,0603,1,10nF,C57112
D1,0603,1,White LED,C2290
"D10, D4, D6",D_SOD-323HE,3,"150V 1A, Schottky",C2842811
D12,D_SMB,1,"130V, Zener",C236106
D2,TO-263-2,1,"Dual Schottky Diode, Common K",C2845075
D3,0603,1,Red LED,C2286
D7,D_PowerDI-123,1,"150V 1A, Schottky bigger",C156325
"D8, D9",D_SOD-323,2,Schottky Diode,C191023
F1,Fuse_Littelfuse-NANO2-451_453,1,20A,C178980
"FB1, FB2",0603,2,FerriteBead_Small,C88986
"J1, J4, J5",Wurth_TerminalBlock_2pin_P5mm_691137710002,3,Screw_Terminal 2pin,C8269
J2,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,1,XH 2pin,C161869
J7,JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical,1,XH 3pin,C161870
"J8, J9",PinSocket_1x20_P2.54mm_Vertical,2,"Socket 20pin, 2.54mm",C5224030
"JP1, JP2",HoTCu-10.2D-0R,2,Jumper_2_Bridged,C5127898
L1,L_12x12mm_H6mm,1,1u,C230666
L2,L_12x12mm_H8mm,1,"100uH, Isat=2.7A",C2453104
L4,BOURNS-PQ2614B,1,10u,C1330029
"Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21",Infineon-TG-TDSON-8-NMOS,8,"N-ch, Vds>=200V, fast switch, low Rds",C412739
"Q2, Q6",Infineon-TG-TDSON-8-NMOS,2,"N-ch, Vds>=60V, fast switch, low Rds",C24199
"Q7, Q8",Infineon-TG-TDSON-8-NMOS,2,"N-ch, Vds>=200V, fast switch, low Rds",C501501
R1,0603,1,1k,C21190
"R14, R23, R24, R25, R26",0603,5,10k,C25804
"R16, R17, R21, R27, R28, R29, R30, R31, R32, R33, R34, R35",0603,12,10,C22859
R18,0805,1,470k 150V,C17709
"R19, R22",0603,2,100k,C25803
R2,2512,1,200,C2765767
R20,0603,1,7.5k,C23234
R3,0805,1,100k 150V,C122537
"R36, R37",1210,2,1,C78022
U1,SOIC-8_3.9x4.9mm_P1.27mm,1,LM5104MX/NOPB,C206493
"U10, U5, U8",SOIC-8_3.9x4.9mm_P1.27mm,3,IR2104S,C2960
U12,SOT-563,1,TMP102,C99269
U2,TO-252-2,1,L78M05ABDT,C58069
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,ACS724LLCTR-30AU,C2155519
U4,AD-MSOP-LT8365,1,LT8365,C673785
U6,SOT-23,1,REF3030,C38423

## Code that names these connections

File firmware-ctrl/config.h:

// SPDX-License-Identifier: BSD-2-Clause
#pragma once

#include <stdint.h>

/**
 * ATtiny1616 controller firmware for the PULSER ctrl board.
 *
 * Device spec: docs/i2c-registers.md (I2C register map) and docs/operation.md
 * (window/timing model). The pulse loop runs in the foreground and the I2C
 * slave runs in the TWI ISR (see main.c).
 */

/**
 * I2C host interface.
 */
#define I2C_DEV_ADDR 0x3c

/**
 * GPIO pin assignments (ctrl board).
 *
 * HV/HC signals are all on PORTA, indicator LEDs on PORTC. I2C uses the TWI0
 * default pins PB0=SCL, PB1=SDA (routed automatically when TWI0 is enabled;
 * no PORTMUX needed).
 */
#define HV_EN_bm    PIN1_bm  // PA1, output: HV gate enable, active H
#define HV_CURR_bm  PIN2_bm  // PA2, input:  comparator out, idle L, H = current detected
#define HV_FAULT_bm PIN3_bm  // PA3, input:  HV board fault, active L; latches permanent fault
#define HC_EN_bm    PIN4_bm  // PA4, output: HC gate enable, active H
#define HC_CURR_bm  PIN5_bm  // PA5, output: HC current setting, PWM driven by TCD0 WOB

// Indicator LEDs, all active H (pin -> LED -> resistor -> GND).
#define LED_OK_bm  PIN0_bm  // PC0, green: successful boot
#define LED_RUN_bm PIN1_bm  // PC1, amber: output enabled
#define LED_ERR_bm PIN2_bm  // PC2, red:   fault (permanent or latched WDT timeout)

/**
 * HC current setting (HC.CURR). See docs/hc.md: PWM in the 10 kHz - 200 kHz
 * band, duty selects the output current, 45% = 10 A (above that the HC board
 * clamps internally). HC only ever carries the 10 A case (CURR = 1 A is
 * HV-only), so the duty is a constant.
 *
 * Driven by TCD0 WOB, which clocks off the 20 MHz oscillator directly rather
 * than CLK_PER; period ticks are therefore counted at 20 MHz independently of
 * F_CPU.
 */
#define HC_CURR_PWM_HZ       100000UL                       // mid-band, 0.5%/tick duty resolution
#define HC_CURR_PWM_DUTY_PCT 45                             // 10 A
#define HC_CURR_PERIOD_TICKS (20000000UL / HC_CURR_PWM_HZ)  // 200
#define HC_CURR_HIGH_TICKS   (HC_CURR_PERIOD_TICKS * HC_CURR_PWM_DUTY_PCT / 100)  // 90

/**
 * Window timing. See docs/operation.md.
 */
#define T_TRAN_US         3    // ignore period of AC transient current (capacitive coupling)
#define T_IG_SHORT_US     7    // ignition delay <= this -> short window
#define T_IG_MAX_US       500  // no ignition within this -> open window
#define CD_GOOD_US        15   // min cooldown after good window (de-arc)
#define CD_SHORT_US       100  // cooldown after short window; must exceed HV internal cooldown
#define CD_OPEN_US        500  // cooldown after open window
#define PULSE_HANDOVER_US 5    // HV+HC overlap during handover

/**
 * Watchdog: while running, host must read RES0 within this window. Timeout
 * is treated as a recoverable fault and stops the device.
 */
#define WDT_TIMEOUT_US 50000  // 50 ms

/**
 * Derived timer-tick constants.
 *
 * Fine timer TCB0 runs at CLK_PER = 20 MHz => 50 ns/tick, so ticks = us * 20.
 * The ignition-detect loop compares against these precomputed thresholds to
 * stay free of multiply/divide. A single window never exceeds the 16-bit range
 * (~3.3 ms), so elapsed time is a wrap-safe uint16 subtraction.
 */
#define TICKS_PER_US      (F_CPU / 1000000UL)
#define T_TRAN_TICKS      (T_TRAN_US * TICKS_PER_US)      // 60
#define T_IG_SHORT_TICKS  (T_IG_SHORT_US * TICKS_PER_US)  // 140
#define T_IG_MAX_TICKS    (T_IG_MAX_US * TICKS_PER_US)    // 10000
#define PROBE_CHECK_TICKS (100u * TICKS_PER_US)           // 2000  (probe latch phase)
#define PROBE_CYCLE_TICKS (500u * TICKS_PER_US)           // 10000 (probe total cycle)

/**
 * Coarse timer TCA0 runs at CLK_PER / 1024 = 51.2 us/tick, used as the software
 * WDT clock. 50 ms / 51.2 us = 976.6 -> 977 ticks. uint16 wrap-safe (period is
 * ~3.35 s, far longer than the 50 ms timeout).
 */
#define WDT_TIMEOUT_TICKS 977u

File firmware-hv/main.c:

// SPDX-License-Identifier: AGPL-3.0-or-later
#define F_CPU 20000000UL

#include <avr/io.h>
#include <stdbool.h>
#include <util/delay.h>

/* -- Pin definitions ------------------------------------------------ */

#define LED_STAT_bm  PIN3_bm  // PC3
#define LED_FAULT_bm PIN2_bm  // PC2
#define GATE_bm      PIN4_bm  // PA4
#define EN_bm        PIN0_bm  // PC0
#define CURR_bm      PIN1_bm  // PC1
#define N_FAULT_bm   PIN0_bm  // PB0
// VTH: PA6, DAC0 output (comparator current threshold); configured in dac_init()

/* -- Pulse configuration -------------------------------------------- */

#define PULSE_DUR_US    10
#define COOLDOWN_DUR_US 100
#define THRESH_MA       500

/* -- Pin initialization --------------------------------------------- */

static void pins_init() {
  // STAT LED PC3: output, initially off
  VPORTC.DIR |= LED_STAT_bm;
  VPORTC.OUT &= ~LED_STAT_bm;

  // N_FAULT PB0 & FAULT LED PC2: outputs, initially de-asserted
  VPORTB.OUT |= N_FAULT_bm;
  VPORTB.DIR |= N_FAULT_bm;
  VPORTC.OUT &= ~LED_FAULT_bm;
  VPORTC.DIR |= LED_FAULT_bm;

  // GATE PA4: output, initially low
  VPORTA.DIR |= GATE_bm;
  VPORTA.OUT &= ~GATE_bm;

  // EN PC0: input, internal pull-up (not ideal, but better than high-Z)
  VPORTC.DIR &= ~EN_bm;
  PORTC.PIN0CTRL = PORT_PULLUPEN_bm;

  // CURR PC1: input, no pull (driven by external comparator)
  VPORTC.DIR &= ~CURR_bm;
}

/* -- STAT LED ------------------------------------------------------- */

static void stat_led(bool on) {
  if (on) {
    VPORTC.OUT |= LED_STAT_bm;
  } else {
    VPORTC.OUT &= ~LED_STAT_bm;
  }
}

/* -- Fault mode ---------------------------------------------------- */

static void fault_mode() __attribute__((noreturn));
static void fault_mode() {
  VPORTA.OUT &= ~GATE_bm;
  VPORTB.OUT &= ~N_FAULT_bm;
  VPORTC.OUT |= LED_FAULT_bm;
  while (1) {
  }
}

/* -- Elapsed-time timer (pulse & duty timing) ---------------------- */

// Free-running 16-bit counter at CLK_PER (20 MHz) -> 20 ticks/µs.
#define TICKS_PER_US (F_CPU / 1000000UL)

static void timer_init() {
  TCB0.CCMP = 0xFFFF;
  TCB0.CTRLB = TCB_CNTMODE_INT_gc;
  TCB0.CTRLA = TCB_CLKSEL_CLKDIV1_gc | TCB_ENABLE_bm;
}

static void timer_reset() {
  TCB0.CNT = 0;
}

// Warning: wraps 3276 µs after timer_reset().
static uint16_t timer_elapsed_ticks() {
  return TCB0.CNT;
}

/* -- DAC initialization (VTH output) ------------------------------- */

static void dac_init() {
  VREF.CTRLA = VREF_DAC0REFSEL_4V34_gc;
  DAC0.DATA = (uint16_t)THRESH_MA * 128 / 434;
  DAC0.CTRLA = DAC_ENABLE_bm | DAC_OUTEN_bm;
}

/* -- Main ----------------------------------------------------------- */

int main() {
  // Run at full 20 MHz: disable prescaler (default is /6)
  CCP = CCP_IOREG_gc;
  CLKCTRL.MCLKCTRLB = 0;

  pins_init();
  dac_init();
  timer_init();
  _delay_ms(10);  // wait DAC & comparator stabilization
  stat_led(true);

  // Current shouldn't be flowing; H indicates some kind of hardware fault.
  if (VPORTC.IN & CURR_bm) {
    fault_mode();
  }

  const uint16_t pulse_ticks = PULSE_DUR_US * TICKS_PER_US;
  const uint16_t cooldown_ticks = COOLDOWN_DUR_US * TICKS_PER_US;

  while (1) {
    // Pre-pulse safety: CURR high without GATE means hardware fault
    //if (VPORTC.IN & CURR_bm) {
//      fault_mode();
    //}

    // Wait for EN rise & activate output
    while (!(VPORTC.IN & EN_bm)) {
    }
    VPORTA.OUT |= GATE_bm;

    // Wait for current to appear, abort if EN drops
    while (!(VPORTC.IN & CURR_bm)) {
      if (!(VPORTC.IN & EN_bm)) {
        VPORTA.OUT &= ~GATE_bm;
        goto wait_en_low;
      }
    }
    timer_reset();  // CURR rise is the reference for both durations

    // Current flowing: hold gate until the pulse elapses or EN drops
    while (timer_elapsed_ticks() < pulse_ticks) {
      if (!(VPORTC.IN & EN_bm)) {
        break;
      }
    }
    VPORTA.OUT &= ~GATE_bm;

    // Thermal duty limit: output stays off for the rest of the window
    while (timer_elapsed_ticks() < cooldown_ticks) {
    }

  wait_en_low:
    while (VPORTC.IN & EN_bm) {
    }
  }
}

File firmware/config.h:

// SPDX-License-Identifier: AGPL-3.0-or-later
#pragma once

#include "hardware/pwm.h"
#include <stdint.h>

/**
 * Externally observable parameters.
 */
#define LED_ERR_BLINK_OFF_MS 250
#define LED_ERR_BLINK_ON_MS 250

#define I2C_DEV_ADDR 0x3b // I2C Device Address
#define I2C_BAUD 400000   // I2C target baud (Hz)

#define THROTTLE_TEMP_C 70 // Above this, start reducing duty factor [℃]
#define MAX_ALLOWED_TEMP 80 // Above this, enter permanent error mode [℃]

#define THROTTLE_DUTY 10 // Max duty factor when throttling [%]

/**
 * GPIO pin definitions & internal parts-specific parameters.
 */
static const uint8_t PIN_I2C_SDA = 0; // I2C0
static const uint8_t PIN_I2C_SCL = 1; // I2C0
static const uint8_t PIN_LED_STATUS = 4;
static const uint8_t PIN_MUX_V0 = 7;      // Controls bridge driver V0
static const uint8_t PIN_MUX_VC = 9;      // Controls bridge driver Vcom
static const uint8_t PIN_TS_I2C_SDA = 14; // Temp sensor chip I2C
static const uint8_t PIN_TS_I2C_SCL = 15; // Temp sensor chip I2C
static const uint8_t PIN_GATE_IG =
    17; // Controls bridge driver for ignition voltage
static const uint8_t PIN_GATE_MAIN_PWM = 18; // Controls buck converter gate
static const uint8_t PWM_GATE_MAIN_PWM = 1;
static const uint8_t PWM_CHAN_GATE_MAIN_PWM = PWM_CHAN_A;
static const uint8_t PIN_CURR_DETECT = 26; // ADC0
static const uint8_t ADC_CURR_DETECT = 0;  // ADC0
static const uint8_t PIN_POWER_PS = 23;

#define HOST_I2C i2c0
#define TS_I2C i2c1

#define TS_I2C_DEV_ADDR 0x49
#define TS_I2C_TIMEOUT_US 500

#define MUX_REFRESH_TIME_US 5
#define MUX_MAX_SETTLE_TIME_US 1
#define DISCHARGE_MAX_SETTLE_TIME_US 5 // PWM delay + MOSFET delay
#define THRESH_MAX_SETTLE_TIME_MS 1    // PWM delay

File firmware-test-integ/config.h:

// SPDX-License-Identifier: BSD-2-Clause
#pragma once

#include <stdint.h>

/**
 * Externally observable parameters.
 */
#define LED_ERR_BLINK_OFF_MS 250
#define LED_ERR_BLINK_ON_MS 250

#define I2C_DEV_ADDR 0x3c
#define I2C_BAUD 400000

/**
 * GPIO pin assignments.
 *
 * GP0/1/2 drive the test rig (HV/HC). GP16/17 expose the I2C slave
 * to a host MCU; these are I2C0 alternate pins on RP2350, so the
 * peripheral stays i2c0 (same as firmware/).
 */
#define PIN_HV_CURR 0    // input — comparator out, idle L, H = current detected
#define PIN_HV_EN 1      // output — HV gate enable, active H
#define PIN_HC_EN 2      // output — HC gate enable, active H
#define PIN_I2C_SDA 16   // I2C0 SDA
#define PIN_I2C_SCL 17   // I2C0 SCL

#define HOST_I2C i2c0

/**
 * Window timing. See docs/operation.md.
 */
#define T_TRAN_US 3          // ignore period of AC transient current (capacitive coupling)
#define T_IG_SHORT_US 7      // ignition delay <= this -> short window
#define T_IG_MAX_US 500      // no ignition within this -> open window
#define CD_GOOD_US 15        // min cooldown after good window (de-arc)
#define CD_SHORT_US 100      // cooldown after short window; must exceed HV internal cooldown
#define CD_OPEN_US 500       // cooldown after open window
#define PULSE_HANDOVER_US 5  // HV+HC overlap during handover

/**
 * Watchdog: while running, host must read RES0 within this window. Timeout
 * is treated as a fault and stops the device.
 */
#define WDT_TIMEOUT_US 50000  // 50 ms

File firmware-ctrl/main.c (part):

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  VPORTA.OUT &= ~(HV_EN_bm | HC_EN_bm | HC_CURR_bm);
  VPORTA.DIR |= HV_EN_bm | HC_EN_bm | HC_CURR_bm;
  VPORTA.DIR &= ~(HV_CURR_bm | HV_FAULT_bm);
  PORTA.PIN3CTRL = PORT_PULLUPEN_bm;  // HV_FAULT (PA3)

  // Indicator LEDs off until boot completes.
  VPORTC.OUT &= ~(LED_OK_bm | LED_RUN_bm | LED_ERR_bm);
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  TCA0.SINGLE.CTRLA = TCA_SINGLE_CLKSEL_DIV1024_gc | TCA_SINGLE_ENABLE_bm;
}

// TCD0: constant-duty PWM on HC_CURR (PA5 = WOB), the HC board's current
// setting. Runs from boot and is never changed, so the HC board's 10 ms setting
// delay is always long expired by the time HC_EN goes active.
static void hc_curr_init() {
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  TCD0.CMPBSET = HC_CURR_PERIOD_TICKS - 1 - HC_CURR_HIGH_TICKS;
  TCD0.CMPBCLR = HC_CURR_PERIOD_TICKS - 1;
  TCD0.CTRLB = TCD_WGMODE_ONERAMP_gc;
  // Override the pin with WOB only; CMPAEN stays clear so WOA leaves PA4
  // (HC_EN) as plain GPIO.
  _PROTECTED_WRITE(TCD0.FAULTCTRL, TCD_CMPBEN_bm);

  while (!(TCD0.STATUS & TCD_ENRDY_bm)) {
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
## Commit log (part)

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2024-08-11 Init (STL 2D slicing)
2024-12-12 Draft of PCB layout
2024-12-19 Set pulse duration & duty factor command-controllable
2024-12-19 Add assembly proc for ED
2025-01-08 Emit tool rotation
2025-01-08 Small doc fix
2025-01-08 Mid-refactor
2025-01-08 Split g-code generator (dicer) and viewer (sim-machine)
2025-01-09 Parametrize tool diameter
2025-01-21 Add skeleton of tool change codes and beef up docs
2025-01-22 Update ED r1 test procedure
2025-01-23 Restructure repo dirs
2025-01-23 Specify ED board (board + FW)
2025-01-23 Add missing info. Change spec to be more user-friendly and safe
2025-01-23 Add safety note
2025-01-23 Add ED PCB cheatsheet for uC. Update I2C to use int reg.
2025-01-23 Update PWM detail
2025-01-24 Draft of ED firmware
2025-01-24 Bug fixes and code refactor
2025-01-24 Fix non-comformant behavior
2025-01-24 Remove no longer relevant ED commands from CTRL-MINI
2025-01-24 Add physical aspect to CTRL-MINI manual
2025-01-27 Added spec for CTRL-MINI
2025-01-27 Fix typos
2025-01-27 Update CTRL-MINI code and doc to prepare support for ED r1
2025-01-27 Impl ED I2C
2025-01-27 Extend regread/regwrite commands for CTRL-MINI
2025-01-28 Wait until ED board is up
2025-01-28 Increase ED wait margin
2025-01-28 Add decial output for regread
2025-01-28 Improve ED monitoring
2025-01-28 Add missing critical section init
2025-01-28 Update ED test instruction & LED error blink
2025-01-28 Orthogonalize command
2025-01-28 Unify to mA to avoid confusion
2025-01-28 Fix GATE output
2025-01-28 Rename pcb & firmware to be more meaningful
2025-01-29 Fix rename typo
2025-02-02 Fix rename
2025-02-08 Add licenses
2025-02-09 Add missing licenses
2025-02-09 Apply strict warning and fix thresh pwm bug
2025-02-09 Fix potential thresh-curr mismatch path
2025-02-10 Enlarge short detection thresh
2025-02-10 1us window GATE noise filtering
2025-02-13 Add bode plot analysis of opamp-mosfet-load-rsense loop
2025-02-15 Attempt to increase speed
2025-02-15 x2 aggressive drill
2025-02-24 PULSER r2 pulse shaper draft
2025-02-25 PULSER r2 schematics ok
2025-02-26 PULSER r2 PCB draft
2025-02-26 Setup 3D files
2025-02-26 Power block done
2025-02-27 Fix caps, improve schematic docs
2025-02-27 before mass vias
2025-02-27 Stich GND by vias
2025-02-27 Improve GND handling
2025-02-27 Pulser r2 gerber
2025-02-27 Update parts soucing
2025-02-27 Alt sources
2025-02-28 Fix FCC conn orientation, fix diode DFM issues
2025-03-01 Update motor for belt drive
2025-03-01 Adjustable move speed
2025-03-01 Remove hard-code from drill speed feedback
2025-03-01 FB control bugfix
2025-03-01 Actual fix
2025-03-03 More intelligent PULSER firmware
2025-03-03 Refactor TMC chip I2C
2025-03-05 Prepare for refactor towards control loop
2025-03-05 Update pulse mutli-byte-read spec
2025-03-05 Support stddev measurement in pulser
2025-03-06 Restructure CORE around control loop
2025-03-06 Better report
2025-03-06 Progress reporting
2025-03-06 Improve status reporting
2025-03-06 Fix I2C type error
2025-03-06 Fix eps related error
2025-03-06 Fix find
2025-03-06 Make pulser default value comformant
2025-03-06 Avoid unncessary double FP
2025-03-06 Improve pulser i/f. Fix find error after 1st time
2025-03-06 Limit feed speed
2025-03-07 Implement XMODEM/SUM
2025-03-07 Increase CORE baud rate
2025-03-07 Feed log extraction
2025-03-07 Improve feed control
2025-03-07 Ring log
2025-03-07 Softer gain
2025-03-07 Inhibit invalid sample in PULSER
2025-03-07 Stabilize new feedback control
2025-03-08 Add static and re-format
2025-03-08 Add convenient stat
2025-03-08 Add missing volatile
2025-03-09 open/short control
2025-03-09 Improve find reliability
2025-03-09 Find issue was due to hardware failure. Revert current change
2025-03-09 r_short/r_open-based position control
2025-03-11 Trying out CadQuery for testbench design
2025-03-16 Draft of PULSER r2 firmware & docs
2025-03-18 Fix temp sensor I2C & current offset
2025-03-20 Implement short detection disable for testing
2025-03-20 Implement testpulser in CORE
2025-03-21 Implement disable_ig_wait for testing
2025-03-21 Optimize pulser control loop to meet 1us deadline
2025-03-21 Relax max current config to 20A
2025-03-21 Fix current conversion
2025-03-21 Adjust CC control
2025-03-21 Relax max duty
2025-03-26 Use PI-control for CC operation
2025-03-26 Reduce gain to lower overshoot
2025-03-27 Dump temperatures when testing current
2025-03-27 PULSER r3 schematics draft
2025-03-27 PULSER r3 PCB DRC pass
2025-03-27 PULSER r3 JLCPCB files
2025-04-07 Update pulser fw for r3 pinouts
2025-04-07 Remove ignition current effect
2025-04-08 Fix denoiser for GATE
2025-04-09 Reduce FFC crosstalk by supplying GND
2025-04-09 Tune motion control parameter
2025-04-28 Start supporting Octopus
2025-05-01 Add instruction
2025-05-01 Add command for quick test
2025-05-11 Gen shell templates
2025-05-11 Add basic CSS
2025-05-12 Refactor spooler handlers
2025-05-12 Control x axis from dashboard
2025-05-12 add missing license
2025-05-22 Remove lagacy desc
2025-06-08 Make it pulser-only
2025-06-08 Cleanup firmware/
2025-07-30 Fix missing 5V input
2025-08-05 EMI reduction & heatsink simplification
    EMI: MOSFET snubber, 36V pi-filter
    heatsink: Parallel mux bridge
2025-08-05 relative kicad libpath
2025-08-05 EMI (ferrite for I2C). Simplify I2C signal
2025-08-05 r4 DRC pass
2025-08-05 LGTM
2025-08-05 Bump revision to r4
2025-08-05 Export r4
2025-08-06 Increase current path width
2025-08-06 Fix mux MOSFET LCSC ids
2025-08-06 Rexport
2025-08-11 Deprecate ignition time stats
2025-08-11 Simplified spec (code not updated yet)
2025-08-12 Update pulse count regs
2025-08-12 Replace gate input w/ ckp timeout
2025-08-12 Update temp register semantics
2025-08-13 Fix activeness logic.
2025-11-12 (crit) Insert resistor to 100V line / (minor) Fix small diode foorprint
2025-11-12 export PCBA data
2025-11-12 Add alternative LCSC no
2025-11-23 Lower ignition detection threshold current to avoid burning 100V circuit
2025-11-23 Refactor
2025-12-02 (maybe) stabilize ignition
2025-12-03 Refactor & give up ig wait after some time to allow cooldown & config/timeout application
2025-12-03 Remove double-fp from get_latest_current_a()
2025-12-03 remove double-fp from current control loop
2025-12-03 Fix timing accuracy of ignite()
2025-12-03 Improve timing accuracy of pulse control
2025-12-04 Ensure Cboot of MUX is always refreshed
2025-12-15 Thermal throttling
2026-01-07 pcb lib: add LT3741-1 & fix part bg colors
2026-01-07 Upgrade KiCad & new discharge exps
2026-01-07 Init test boards for HV, HC modules
2026-01-08 Draft architecture for both HC & HV
2026-01-11 HC testboard: schem draft ok
2026-01-12 HC test board pcb draft ok
2026-01-12 cleanup
2026-01-13 HV schem draft ok
2026-01-13 HV lcsc & footprint assigned
2026-01-13 HC, HV: PCB DRC pass
2026-01-14 Add I/O descs
2026-01-14 pcb: replace abs path w/ relative path
2026-01-14 HV, HC: export for jlcpcb
2026-01-14 HC: add missing LCSC number
2026-01-14 HV: Fix wrong LCSC number
2026-02-04 Add LT3763 symbol to lib
2026-02-04 HC TestBoards r2 schem draft ok
2026-02-05 HC TestBoard r2 PCB draft ok
2026-02-06 JLCPCB ready
2026-02-06 HV TestBoard r2 schem draft ok. mock firmware build env.
2026-02-06 HV TestBoard r2 pcb ok
2026-02-27 HV-r2 test firmware
2026-02-28 DAC stabilization wait
2026-04-15 P2HV r3 schem
2026-04-15 P2HV r3 PCB
2026-05-05 Test firmware for TB integration
2026-05-06 Keep 5us HV->HC handover period
2026-05-06 Prevent mis-classification of short pulse as normal pulse
2026-05-07 Update readme; elaborate on V1 & V2
2026-05-08 Adjust pulse cooldown based on measurement
2026-05-11 Implement prod-pulser compatible interface in firmware-test-integ
2026-05-22 Got rid of unstable V1
2026-05-22 Record test controller (breardboard) schematics
2026-05-22 Record inter-board wiring
2026-05-22 Record current testboard modifications as schematics
2026-05-28 Add operation model
2026-05-28 Improve operation diagram
2026-05-28 Spec out new I2C register map w/ probe function
2026-05-31 Implement new register map (allows pure probing)
2026-06-01 Reject spurious probe (in water)
2026-06-04 Distinguish tran noise vs short
2026-06-10 For some reason, this causes eff_duty to jump up 9x (5%->45%) for "250us, 10A, 90%" configuration
2026-06-24 Finer grained pulse control
2026-06-25 Cooling design test
2026-06-25 Back-fan design
2026-06-29 Bigger duct & HS
2026-06-30 Add module foot
2026-06-30 Add TPSM365 to lib
2026-06-30 Draft ctrl r2 schem
