File: pcb/PULSER-testboard-hv/PULSER-testboard-hv.kicad_sch (KiCad schematic)
At the start: 21 parts, among them J1 Screw_Terminal 2pin, J2 Screw_Terminal 2pin, J3 Conn_01x02_Pin, J4 Conn_01x02_Pin, Q1 N-ch, Vds>=60V, fast switch, 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, U1 INA281A2, U10 LM317_DPAK, U2 LTC7001, U3 TL783, U7 TLV3201

Commit message: HV schem draft ok
Parts:
- added C15, C21, C23: 0.1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C22: 1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added F1: 2A, symbol Device:Fuse
- added JP1, JP2, JP3, JP5: Jumper_2_Small_Open, symbol Jumper:Jumper_2_Small_Open
- added JP4, JP6: Jumper_2_Small_Bridged, symbol Jumper:Jumper_2_Small_Bridged
- added R12: 2.4, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R18: 6.2, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R19: 1.3, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R20: .62, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R21, R23: 9.1k, symbol Device:R
- added R22: 36k, symbol Device:R
- added R24, R25: 10k, symbol Device:R
- added SW2: SW_DIP_x04, Button_Switch_SMD:SW_DIP_SPSTx04_Slide_9.78x12.34mm_W8.61mm_P2.54mm, symbol Switch:SW_DIP_x04
- added TP1, TP2, TP3, TP4, TP5, TP6: TestPoint_Small, symbol Connector:TestPoint_Small
- D1: value 150V 1A -> 150V 2A
- Q1: footprint SparkAll:Infineon-TG-TDSON-8-NMOS -> Package_TO_SOT_SMD:SOT-223-3_TabPin2; LCSC C24199 -> C537930
- R2: value 2.5 -> 82k; footprint Resistor_SMD:R_0603_1608Metric -> (none); LCSC C23234 -> (none)
- R3: renamed from R5; value 9.1k -> 75k
- R4: renamed from R6; value 1k -> 3.9k
- renumbered C9 to C3, C10 to C4, J4 to J3, J3 to J4, R9 to R5, R10 to R6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
Connections:
- net +36V: now also F1.2; no longer J1.2 (Pin_2)
- net +5V: now also R2.1, C15.1, C21.1, C23.1, R22.1, R24.1
- net Boost Converter/VOUT: now also C1.1, TP1.1
- net GND: now also C15.2, C21.2, C22.2, C23.2, JP4.1 (A), JP6.1 (A), R21.2, R23.2, R25.2; no longer U3.2 (VCCUV), U3.5 (OVLO)
- net at Q1.G, U3.6 (TGDN), U3.7 (TGUP): now also TP5.1
- net at C2.2, Q1.S, R1.1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: now also C22.1, TP2.1
- net at R1.2, U1.3 (IN), U2.4 (Vin-): now also TP3.1; no longer C1.1
- net IR_VO: now reaches U1.2 (OUT)
- net IR_VO: now also JP1.1 (A), JP2.1 (A), JP3.1 (A), JP5.1 (A); no longer R2.1
- net IR_AD: now reaches D1.2 (A), U1.1 (ADJ/GND)
- net IR_AD: now also R12.2, R18.2, R19.2, R20.2, TP4.1; no longer R2.2
- net VTH_50: now reaches R3.2, R4.1
- net VTH_50: now also SW2.1; no longer U4.4 (-)
- net at C2.1, U3.9 (BST): now also TP6.1
- new net: F1.1, J1.2 (Pin_2)
- new net: JP1.2 (B), R12.1
- new net: JP2.2 (B), R19.1
- new net: JP5.2 (B), R18.1
- new net: JP6.2 (B), U3.5 (OVLO)
- new net: JP3.2 (B), R20.1
- new net: JP4.2 (B), U3.2 (VCCUV)
- new net VTH: SW2.5, SW2.6, SW2.7, SW2.8, U4.4 (-)
- new net VTH_100: R2.2, R21.1, SW2.2
- new net VTH_200: R22.2, R23.1, SW2.3
- new net VTH_500: R24.2, R25.1, SW2.4
Other:
- note added: "50mA 100mA (default) 200mA 500mA"
- note added: "I=1.25V/R"
- note added: "I=1A"
- note added: "I=200mA"
- note added: "I=2A"
- note added: "I=500mA (default)"
- note added: "IRFL4315"
- note added: "Vth = Ith * Rsense (100m) * gain (50)"
- note added: "bypass caps"
- note added: "peak: negligible"
- note removed: "100mA -> 10mV -> 0.5V"
- note removed: "500mA -> 50mV"
- note removed: "500mA -> 50mV -> 2.5V"
- note removed: "500mV"
- note removed: "I=500mA"
- moved on the sheet: C1, D1, J2, R3, R4, U1, U2

Commit message: HV lcsc & footprint assigned
Parts:
- removed Q1: N-ch, Vds>=60V, fast switch, low Rds, Package_TO_SOT_SMD:SOT-223-3_TabPin2, symbol Device:Q_NMOS
- added Q2: Q_NMOS_GDS, Package_TO_SOT_SMD:SOT-223-3_TabPin2, symbol Transistor_FET:Q_NMOS_GDS
- C1: value 1u -> 100nF 200V; footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_1206_3216Metric; LCSC C21120 -> C113894
- C2: renamed from C22; value 1u -> 100nF 200V; footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_1206_3216Metric; LCSC C21120 -> C113894
- C3: renamed from C2; value 0.1u -> 100nF 200V; footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_1206_3216Metric; LCSC C21120 -> C113894
- C4: renamed from C15; LCSC C21120 -> C14663
- C5: renamed from C21; LCSC C21120 -> C14663
- C6: renamed from C23; LCSC C21120 -> C14663
- C7: renamed from C3; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C14663
- C8: renamed from C4; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C15849
- D1: footprint Diode_SMD:D_PowerDI-123 -> Diode_SMD:D_SMC; LCSC C156325 -> C241922
- F1: footprint (none) -> Fuse:Fuse_Littelfuse-NANO2-451_453; LCSC (none) -> C142852
- J3, J4: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical; LCSC (none) -> C42431798
- JP1: renamed from JP5; footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical; LCSC (none) -> C42431798
- JP2: renamed from JP1; footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical; LCSC (none) -> C42431798
- JP3: renamed from JP4; footprint (none) -> Jumper:SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; now left out of the parts list
- JP4: renamed from JP2; footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical; LCSC (none) -> C42431798
- JP5: renamed from JP6; footprint (none) -> Jumper:SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; now left out of the parts list
- JP6: renamed from JP3; footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical; LCSC (none) -> C42431798
- R1: value 100m -> 100mΩ 120V; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_1206_3216Metric; LCSC C23234 -> C25334
- R10: renamed from R4; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23018
- R11: renamed from R21; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23260
- R12: renamed from R23; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23260
- R13: renamed from R25; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C25804
- R14: renamed from R5; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C22966
- R15: renamed from R6; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23253
- R2: renamed from R18; value 6.2 -> 6.2Ω 120V; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_1206_3216Metric
- R3: renamed from R12; value 2.4 -> 2.4Ω 120V; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_1206_3216Metric; LCSC C23234 -> C15544
- R4: renamed from R19; value 1.3 -> 1.3Ω 120V; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_1206_3216Metric; LCSC C23234 -> C5151639
- R5: renamed from R20; value .62 -> 0.62Ω 120V; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_1206_3216Metric; LCSC C23234 -> C25341
- R6: renamed from R3; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23242
- R7: renamed from R2; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23254
- R8: renamed from R22; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C23147
- R9: renamed from R24; footprint (none) -> Resistor_SMD:R_0603_1608Metric; LCSC (none) -> C25804
- TP1, TP2, TP3, TP4, TP5, TP6: footprint (none) -> TestPoint:TestPoint_Pad_D1.5mm; now left out of the parts list
- U1: footprint Package_TO_SOT_SMD:TO-263-3_TabPin2 -> Package_TO_SOT_THT:TO-220-3_Vertical; LCSC (none) -> C96088
- U2: LCSC (none) -> C2908677
- U3: footprint Analog_Devices-MSE-10-05-08-1664-0-I-* -> Package_SO:MSOP-10-1EP_3x3mm_P0.5mm_EP1.68x1.88mm; LCSC (none) -> C690094
- U4: LCSC (none) -> C105188
- U5: LCSC (none) -> C68136
- renumbered SW2 to SW1
Connections:
- net Boost Converter/VOUT: now also Q2.2 (D)
- net at TP5.1, U3.6 (TGDN), U3.7 (TGUP): now also Q2.1 (G)
- net at C2.1, C3.2, R1.1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: now also Q2.3 (S)

Commit message: HC, HV: PCB DRC pass
Parts:
- renumbered Q2 to Q1
Connections:
- net GND: now also C7.1, C8.1, R15.2
Changed lines of the file:
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@@
 	)
 	(junction
-		(at 69.85 184.15)
-		(diameter 0)
-		(color 0 0 0 0)
-	)
-	(junction
 		(at 157.48 39.37)
 		(diameter 0)
@@
 	(wire
 		(pts
-			(xy 87.63 184.15) (xy 69.85 184.15)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 220.98 49.53) (xy 196.85 49.53)
 		)
@@
 	(wire
 		(pts
-			(xy 69.85 184.15) (xy 33.02 184.15)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 73.66 33.02) (xy 73.66 39.37)
 		)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "Q2"
+		(property "Reference" "Q1"
 			(at 120.65 34.036 90)
 			(effects
@@
 			(project ""
 				(path "/853931f0-9d2b-49ab-aae3-2a7153967e0f"
-					(reference "Q2")
+					(reference "Q1")
 					(unit 1)
 				)
@@
 	(symbol
 		(lib_id "power:GND")
+		(at 33.02 184.15 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "#PWR056"
+			(at 33.02 190.5 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "GND"
+			(at 33.02 189.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" ""
+			(at 33.02 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 33.02 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
+			(at 33.02 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "PULSER-testboard-hv"
+				(path "/853931f0-9d2b-49ab-aae3-2a7153967e0f"
+					(reference "#PWR056")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
+		(lib_id "power:GND")
 		(at 166.37 153.67 0)
 		(unit 1)
@@
 	)
 	(symbol
+		(lib_id "power:GND")
+		(at 87.63 184.15 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "#PWR059"
+			(at 87.63 190.5 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "GND"
+			(at 87.63 189.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" ""
+			(at 87.63 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 87.63 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
+			(at 87.63 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "PULSER-testboard-hv"
+				(path "/853931f0-9d2b-49ab-aae3-2a7153967e0f"
+					(reference "#PWR059")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
 		(lib_id "Device:R")
 		(at 153.67 147.32 0)
@@
 					(unit 1)
 				)
+			)
+		)
+	)
+	(symbol
+		(lib_id "power:GND")
+		(at 69.85 184.15 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "#PWR058"
+			(at 69.85 190.5 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "GND"
+			(at 69.85 189.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" ""
+			(at 69.85 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 69.85 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
+			(at 69.85 184.15 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "PULSER-testboard-hv"
+				(path "/853931f0-9d2b-49ab-aae3-2a7153967e0f"
+					(reference "#PWR058")
+					(unit 1)
+				)

Commit message: HV: Fix wrong LCSC number
Parts:
- R2: LCSC C23234 -> C25344
Changed lines of the file:
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@@
 			)
 		)
-		(property "LCSC" "C23234"
+		(property "LCSC" "C25344"
 			(at 219.71 59.69 0)
 			(effects

Commit message: HV TestBoard r2 schem draft ok. mock firmware build env.
Parts:
- removed C2: 100nF 200V, Capacitor_SMD:C_1206_3216Metric, symbol Device:C
- removed JP6: Jumper_2_Small_Open, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Jumper:Jumper_2_Small_Open
- removed R10: 3.9k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R11, R12: 9.1k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R13, R9: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R2: 6.2Ω 120V, Resistor_SMD:R_1206_3216Metric, symbol Device:R
- removed R3: 2.4Ω 120V, Resistor_SMD:R_1206_3216Metric, symbol Device:R
- removed R4: 1.3Ω 120V, Resistor_SMD:R_1206_3216Metric, symbol Device:R
- removed R5: 0.62Ω 120V, Resistor_SMD:R_1206_3216Metric, symbol Device:R
- removed R7: 82k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R8: 36k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed SW1: SW_DIP_x04, Button_Switch_SMD:SW_DIP_SPSTx04_Slide_9.78x12.34mm_W8.61mm_P2.54mm, symbol Switch:SW_DIP_x04
- removed U1: TL783, Package_TO_SOT_THT:TO-220-3_Vertical, symbol Regulator_Linear:LD1086D2MTR
- added D3: LED, LED_SMD:LED_0603_1608Metric, symbol Device:LED
- added D5: 150V 2A, Diode_SMD:D_SMC, symbol Device:D_Schottky
- added L2, L3, L4, L5: 220u, Inductor_THT:L_Toroid_Vertical_L16.0mm_W8.0mm_P7.62mm, symbol Device:L
- added TP10, TP7, TP8, TP9: TestPoint_Small, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint_Small
- R6: value 75k -> 10k; LCSC C23242 -> C25804
Connections:
- net IR_AD is gone; now on an unnamed net: D1.2 (A), TP4.1
- net VTH_50 is gone; now on net GND: R6.2
- net +5V: no longer R6.1
- net CURR: now also D3.2 (A), TP10.1
- net GATE: now also TP7.1
- net GND: now also D5.2 (A)
- net VTH: now also TP8.1
- net at JP2.2 (B): now also JP1.2 (B), JP4.2 (B), L5.2
- net at U2.1 (OUT), U4.3 (+): now also TP9.1
- net at C3.2, Q1.3 (S), R1.1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: now also D5.1 (K)
- net at R1.2, TP3.1, U2.4 (Vin-): now also L2.1
- removed net IR_VO: JP1.1 (A), JP2.1 (A), JP4.1 (A)
- new net: JP2.1 (A), L2.2, L3.1
- new net: D3.1 (K), R6.1
- new net: JP1.1 (A), L3.2, L4.1
- new net: JP4.1 (A), L4.2, L5.1
Other:
- sheet Pulse Controller ports: added VTH; removed none
- note removed: "50mA 100mA (default) 200mA 500mA"
- note removed: "I=1.25V/R"
- note removed: "I=1A"
- note removed: "I=200mA"
- note removed: "I=2A"
- note removed: "I=500mA (default)"
- note removed: "Vth = Ith * Rsense (100m) * gain (50)"
- note removed: "peak: 50W (dur<5us) avg: 2.5W (5% duty)"
- note removed: "peak: 630mW avg: 32mW"
- moved on the sheet: D1, J2, JP2, TP4

Commit message: HV TestBoard r2 pcb ok
Other:
- note added: "CURR (RED)"
Changed lines of the file:
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@@
 		(comment 1 "夕月霞")
+	)
+	(text "CURR (RED)"
+		(exclude_from_sim no)
+		(at 190.5 110.744 0)
+		(effects
+			(font
+				(size 1 1)
+			)
+			(justify left)
+		)
 	)
 	(text "\"2\": gain=50"

Commit message: P2HV r3 schem
Parts:
- added C2: 1uF 200V, Capacitor_SMD:C_1812_4532Metric, symbol Device:C
- added D6: 150V 250mA, symbol Device:D
- added JP6: Jumper_2_Small_Open, symbol Jumper:Jumper_2_Small_Open
- added R2: 10, symbol Device:R
- added R3: 100k, symbol Device:R
- R6: value 10k -> 1k; LCSC C25804 -> (none)
Connections:
- net +5V: now also D6.2 (A)
- net Boost Converter/VOUT: now also C2.1
- net GND: now also C2.2, JP6.2 (B), R2.2, R3.2; no longer D5.2 (A)
- net at D1.1 (K), J2.1 (Pin_1): now also R3.1
- net at C3.1, TP6.1, U3.9 (BST): now also D6.1 (K)
- new net: D5.2 (A), JP6.1 (A), R2.1
Other:
- note added: "flywheel damping"
- note added: "peak: 100mW"
- note added: "prevent floating output for easier measurement"
- moved on the sheet: C3, C4, C5, C6, D3, D5, R1, R6, TP10, TP2, TP6, TP9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
