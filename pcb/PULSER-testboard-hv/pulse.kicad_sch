File: pcb/PULSER-testboard-hv/pulse.kicad_sch (KiCad schematic)
At the start: 21 parts, among them J1 Screw_Terminal 2pin, J2 Screw_Terminal 2pin, J3 Conn_01x02_Pin, J4 Conn_01x02_Pin, Q1 N-ch, Vds>=60V, fast switch, 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, U1 INA281A2, U10 LM317_DPAK, U2 LTC7001, U3 TL783, U7 TLV3201

Commit message: Draft architecture for both HC & HV
Parts:
- removed C1: 1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C10: 1u, symbol Device:C_Small
- removed C2: 0.1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C9: 0.1u, symbol Device:C_Small
- removed D1: 150V 1A, Diode_SMD:D_PowerDI-123, symbol Device:D_Schottky
- removed J1, J2: Screw_Terminal 2pin, SparkAll:Wurth_TerminalBlock_2pin_P5mm_691137710002, symbol Connector:Screw_Terminal_01x02
- removed J3, J4: Conn_01x02_Pin, symbol Connector:Conn_01x02_Pin
- removed Q1: N-ch, Vds>=60V, fast switch, low Rds, SparkAll:Infineon-TG-TDSON-8-NMOS, symbol Device:Q_NMOS
- removed R1: 100m, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R10: 820, symbol Device:R
- removed R2: 2.5, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R5: 9.1k, symbol Device:R
- removed R6: 1k, symbol Device:R
- removed R9: 270, symbol Device:R
- removed U1: INA281A2, Package_TO_SOT_SMD:SOT-23-5, symbol Amplifier_Current:INA281A2
- removed U10: LM317_DPAK, Package_TO_SOT_SMD:TO-252-2, symbol Regulator_Linear:LM317_TO-252
- removed U2: LTC7001, Analog_Devices-MSE-10-05-08-1664-0-I-*, symbol SparkAll:LTC7001
- removed U3: TL783, Package_TO_SOT_SMD:TO-263-3_TabPin2, symbol Regulator_Linear:LD1086D2MTR
- removed U7: TLV3201, Package_TO_SOT_SMD:SOT-23-5, symbol Comparator:TLV7031DBV
- added C3: 560p, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C4, C5, C6, C7: 0.1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C8: 10n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added R3: 8.2k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R4: 9.1k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added U5, U9: LMC555xMM, Package_SO:VSSOP-8_3x3mm_P0.65mm, symbol Timer:LMC555xMM
- added U6, U8: 74HC00, symbol 74xx:74HC00
Connections:
- net +5V: now also C4.2, C5.2, C6.2, C7.2, R3.2, R4.2, U5.4 (~{RST}), U5.8 (VCC), U6.14 (VCC), U8.14 (VCC), U9.4 (~{RST}), U9.8 (VCC)
- net CURR: now also U8.1, U8.2
- net EN: now also U6.1
- net GATE: now also U6.6
- net GND: now also C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, U5.1 (GND), U6.7 (GND), U8.10, U8.12, U8.13, U8.4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
- new net: C8.2, R4.1, U9.6 (THRES), U9.7 (DISCH)
- new net: U6.12, U6.8
- new net: C3.2, R3.1, U5.6 (THRES), U5.7 (DISCH)
- new net: U6.3, U6.4, U6.5
- new net COOLDOWN: U6.13, U9.3 (OUT)
- new net GATE_OK: U6.11, U6.2
- new net PULSE: U5.3 (OUT), U6.10, U6.9
- new net ~{CURR}: U5.2 (TRIG), U8.3, U9.2 (TRIG)
Other:
- removed sheet Boost Converter
- removed sheet Pulse Controller
- note added: "100us pulse"
- note added: "5us pulse"
- note added: "GATE = EN & GATE_OK GATE_OK = PULSE | ~COOLDOWN = ~ (!PULSE & COOLDOWN)"
- note added: "unused"
- note removed: ""2": gain=50"
- note removed: "100V"
- note removed: "100mA -> 10mV -> 0.5V"
- note removed: "500mA -> 50mV"
- note removed: "500mA -> 50mV -> 2.5V"
- note removed: "500mV"
- note removed: "5V"
- note removed: "5V digital output"
- note removed: "I=500mA"
- note removed: "digital input (thresh=2V) abs max 5.3V"
- note removed: "peak: 400mW avg: 20mW"
- note removed: "peak: 50W (dur<5us) avg: 2.5W (5% duty)"
- note removed: "peak: 630mW avg: 32mW"

Commit message: HV schem draft ok
Parts:
- removed C3: 560p, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C8: 10n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed R3: 8.2k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R4: 9.1k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added C13, C20: 100n, symbol Device:C_Small
- added C16, C17: 330p, symbol Device:C_Small
- added C18, C19: 470p, symbol Device:C_Small
- added R11: 910, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R13: 2.7k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R14: 5.6k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R15: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R16: 20k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R17: 9.1k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added SW1: SW_DIP_x04, Button_Switch_SMD:SW_DIP_SPSTx04_Slide_9.78x12.34mm_W8.61mm_P2.54mm, symbol Switch:SW_DIP_x04
- added SW3: SW_DIP_x02, symbol Switch:SW_DIP_x02
- renumbered C5 to C10, C6 to C11, C4 to C12, C7 to C14, U9 to U10, U8 to U7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
Connections:
- net +5V: now also R11.2, R13.2, R14.2, R15.2, R16.2, R17.2
- net GND: now also C13.1, C16.1, C17.1, C18.1, C19.1, C20.1
- net TH_CL: now reaches U10.6 (THRES), U10.7 (DISCH)
- net TH_CL: now also SW3.3, SW3.4
- net TH_P: now reaches U9.6 (THRES), U9.7 (DISCH)
- net TH_P: now also SW1.5, SW1.6, SW1.7, SW1.8
- new net TH_CL_0.1m: C13.2, R11.1, SW3.1
- new net TH_CL_1m: C20.2, R17.1, SW3.2
- new net TH_P_1: C16.2, R13.1, SW1.1
- new net TH_P_10: C19.2, R16.1, SW1.4
- new net TH_P_2: C17.2, R14.1, SW1.2
- new net TH_P_5: C18.2, R15.1, SW1.3
Other:
- note added: "100us (default) 1ms (t=1.1 RC)"
- note added: "1us 2us 5us (default) 10us (t=1.1 RC)"
- note removed: "100us pulse"
- note removed: "5us pulse"
- moved on the sheet: C12, C14, U10, U8C, U8D, U9

Commit message: HV lcsc & footprint assigned
Parts:
- C14: renamed from C10; LCSC C21120 -> C14663
- C15: renamed from C11; LCSC C21120 -> C14663
- C16, C17: footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C1664
- C18, C19: footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C1620
- C20: renamed from C12; LCSC C21120 -> C14663
- C21: renamed from C14; LCSC C21120 -> C14663
- C22: renamed from C13; value 100n -> 0.1u; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C14663
- C23: renamed from C20; value 100n -> 0.1u; footprint (none) -> Capacitor_SMD:C_0603_1608Metric; LCSC (none) -> C14663
- R20: renamed from R13; LCSC C23234 -> C13167
- R21: renamed from R14; LCSC C23234 -> C23189
- R22: renamed from R15; LCSC C23234 -> C25804
- R23: renamed from R16; LCSC C23234 -> C4184
- R24: renamed from R11; LCSC C23234 -> C23264
- R25: renamed from R17; LCSC C23234 -> C23260
- SW3: footprint (none) -> Button_Switch_SMD:SW_DIP_SPSTx02_Slide_9.78x7.26mm_W8.61mm_P2.54mm; LCSC (none) -> C3293152
- U10, U9: footprint Package_SO:VSSOP-8_3x3mm_P0.65mm -> Package_SO:SOIC-8_3.9x4.9mm_P1.27mm; LCSC (none) -> C90760
- U7, U8: footprint (none) -> Package_SO:TSSOP-14_4.4x5mm_P0.65mm; LCSC (none) -> C6807
- renumbered SW1 to SW2

Commit message: HC, HV: PCB DRC pass
Parts:
- added R26, R27: 10M, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added TP10, TP12, TP13, TP14, TP7, TP8, TP9: TestPoint_Small, TestPoint:TestPoint_Pad_D1.5mm, symbol Connector:TestPoint_Small
Connections:
- net +5V: now also R27.2
- net COOLDOWN: now also TP10.1
- net GATE: now also TP13.1
- net GATE_OK: now also TP12.1
- net GND: now also R26.1
- net PULSE: now also TP9.1
- net TH_CL: now also R27.1, TP8.1
- net TH_P: now also R26.2, TP7.1
- net ~{CURR}: now also TP14.1
Other:
- note added: "SW open (always cooldown)"
- note added: "SW open (no pulse)"
